v {xschem version=3.0.0 file_version=1.2 }
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=CMP_OP}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=CMP_ON}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=EN}
C {devices/iopin.sym} 0 60 0 0{name=p3 lab=RST_N}
C {devices/iopin.sym} 0 80 0 0{name=p4 lab=ENO}
C {devices/iopin.sym} 0 100 0 0{name=p5 lab=CHL_OP}
C {devices/iopin.sym} 0 120 0 0{name=p6 lab=CHL_ON}
C {devices/iopin.sym} 0 140 0 0{name=p7 lab=AVDD}
C {devices/iopin.sym} 0 160 0 0{name=p8 lab=AVSS}
C {SUN_SAR9B_SK130NM/TAPCELLB_CV.sym} 400 0 0 0 {name=XA0}
N 340.0 0.0 380.0 0.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 0.0 0 0  {name=l0 sig_type=std_logic lab=AVDD }
N 340.0 20.0 380.0 20.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 20.0 0 0  {name=l1 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SAREMX1_CV.sym} 400 60 0 0 {name=XA1}
N 340.0 60.0 380.0 60.0{lab=CMP_OP}
C {devices/lab_pin.sym} 340.0 60.0 0 0  {name=l2 sig_type=std_logic lab=CMP_OP }
N 340.0 80.0 380.0 80.0{lab=CMP_ON}
C {devices/lab_pin.sym} 340.0 80.0 0 0  {name=l3 sig_type=std_logic lab=CMP_ON }
N 340.0 100.0 380.0 100.0{lab=EN}
C {devices/lab_pin.sym} 340.0 100.0 0 0  {name=l4 sig_type=std_logic lab=EN }
N 340.0 120.0 380.0 120.0{lab=ENO}
C {devices/lab_pin.sym} 340.0 120.0 0 0  {name=l5 sig_type=std_logic lab=ENO }
N 340.0 140.0 380.0 140.0{lab=RST_N}
C {devices/lab_pin.sym} 340.0 140.0 0 0  {name=l6 sig_type=std_logic lab=RST_N }
N 340.0 160.0 380.0 160.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 160.0 0 0  {name=l7 sig_type=std_logic lab=AVDD }
N 340.0 180.0 380.0 180.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 180.0 0 0  {name=l8 sig_type=std_logic lab=AVSS }
N 340.0 200.0 380.0 200.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 200.0 0 0  {name=l9 sig_type=std_logic lab=AVDD }
N 340.0 220.0 380.0 220.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 220.0 0 0  {name=l10 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/IVX1_CV.sym} 400 260 0 0 {name=XA2}
N 360.0 260.0 400.0 260.0{lab=ENO}
C {devices/lab_pin.sym} 360.0 260.0 0 0  {name=l11 sig_type=std_logic lab=ENO }
N 440.0 260.0 480.0 260.0{lab=LCK_N}
C {devices/lab_pin.sym} 440.0 260.0 0 0  {name=l12 sig_type=std_logic lab=LCK_N }
N 410.0 220.0 450.0 220.0{lab=AVDD}
C {devices/lab_pin.sym} 410.0 220.0 0 0  {name=l13 sig_type=std_logic lab=AVDD }
N 410.0 300.0 450.0 300.0{lab=AVSS}
C {devices/lab_pin.sym} 410.0 300.0 0 0  {name=l14 sig_type=std_logic lab=AVSS }
N 390.0 220.0 430.0 220.0{lab=AVDD}
C {devices/lab_pin.sym} 390.0 220.0 0 0  {name=l15 sig_type=std_logic lab=AVDD }
N 390.0 300.0 430.0 300.0{lab=AVSS}
C {devices/lab_pin.sym} 390.0 300.0 0 0  {name=l16 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SARLTX1_CV.sym} 400 360 0 0 {name=XA4}
N 340.0 360.0 380.0 360.0{lab=CMP_OP}
C {devices/lab_pin.sym} 340.0 360.0 0 0  {name=l17 sig_type=std_logic lab=CMP_OP }
N 340.0 380.0 380.0 380.0{lab=CHL_OP}
C {devices/lab_pin.sym} 340.0 380.0 0 0  {name=l18 sig_type=std_logic lab=CHL_OP }
N 340.0 400.0 380.0 400.0{lab=RST_N}
C {devices/lab_pin.sym} 340.0 400.0 0 0  {name=l19 sig_type=std_logic lab=RST_N }
N 340.0 420.0 380.0 420.0{lab=EN}
C {devices/lab_pin.sym} 340.0 420.0 0 0  {name=l20 sig_type=std_logic lab=EN }
N 340.0 440.0 380.0 440.0{lab=LCK_N}
C {devices/lab_pin.sym} 340.0 440.0 0 0  {name=l21 sig_type=std_logic lab=LCK_N }
N 340.0 460.0 380.0 460.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 460.0 0 0  {name=l22 sig_type=std_logic lab=AVDD }
N 340.0 480.0 380.0 480.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 480.0 0 0  {name=l23 sig_type=std_logic lab=AVSS }
N 340.0 500.0 380.0 500.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 500.0 0 0  {name=l24 sig_type=std_logic lab=AVDD }
N 340.0 520.0 380.0 520.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 520.0 0 0  {name=l25 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SARLTX1_CV.sym} 400 560 0 0 {name=XA5}
N 340.0 560.0 380.0 560.0{lab=CMP_ON}
C {devices/lab_pin.sym} 340.0 560.0 0 0  {name=l26 sig_type=std_logic lab=CMP_ON }
N 340.0 580.0 380.0 580.0{lab=CHL_ON}
C {devices/lab_pin.sym} 340.0 580.0 0 0  {name=l27 sig_type=std_logic lab=CHL_ON }
N 340.0 600.0 380.0 600.0{lab=RST_N}
C {devices/lab_pin.sym} 340.0 600.0 0 0  {name=l28 sig_type=std_logic lab=RST_N }
N 340.0 620.0 380.0 620.0{lab=EN}
C {devices/lab_pin.sym} 340.0 620.0 0 0  {name=l29 sig_type=std_logic lab=EN }
N 340.0 640.0 380.0 640.0{lab=LCK_N}
C {devices/lab_pin.sym} 340.0 640.0 0 0  {name=l30 sig_type=std_logic lab=LCK_N }
N 340.0 660.0 380.0 660.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 660.0 0 0  {name=l31 sig_type=std_logic lab=AVDD }
N 340.0 680.0 380.0 680.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 680.0 0 0  {name=l32 sig_type=std_logic lab=AVSS }
N 340.0 700.0 380.0 700.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 700.0 0 0  {name=l33 sig_type=std_logic lab=AVDD }
N 340.0 720.0 380.0 720.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 720.0 0 0  {name=l34 sig_type=std_logic lab=AVSS }
