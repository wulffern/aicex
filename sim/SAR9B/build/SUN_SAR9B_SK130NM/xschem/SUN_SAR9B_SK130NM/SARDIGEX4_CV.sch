v {xschem version=3.0.0 file_version=1.2 }
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=CMP_OP}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=CMP_ON}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=EN}
C {devices/iopin.sym} 0 60 0 0{name=p3 lab=RST_N}
C {devices/iopin.sym} 0 80 0 0{name=p4 lab=ENO}
C {devices/iopin.sym} 0 100 0 0{name=p5 lab=DONE}
C {devices/iopin.sym} 0 120 0 0{name=p6 lab=CP0}
C {devices/iopin.sym} 0 140 0 0{name=p7 lab=CP1}
C {devices/iopin.sym} 0 160 0 0{name=p8 lab=CN0}
C {devices/iopin.sym} 0 180 0 0{name=p9 lab=CN1}
C {devices/iopin.sym} 0 200 0 0{name=p10 lab=CEIN}
C {devices/iopin.sym} 0 220 0 0{name=p11 lab=CEO}
C {devices/iopin.sym} 0 240 0 0{name=p12 lab=CKS}
C {devices/iopin.sym} 0 260 0 0{name=p13 lab=VREF}
C {devices/iopin.sym} 0 280 0 0{name=p14 lab=AVDD}
C {devices/iopin.sym} 0 300 0 0{name=p15 lab=AVSS}
C {SUN_SAR9B_SK130NM/DMY_CV.sym} 400 0 0 0 {name=XA0a}
C {SUN_SAR9B_SK130NM/SARMRYX1_CV.sym} 400 40 0 0 {name=XA1}
N 340.0 40.0 380.0 40.0{lab=CMP_OP}
C {devices/lab_pin.sym} 340.0 40.0 0 0  {name=l0 sig_type=std_logic lab=CMP_OP }
N 340.0 60.0 380.0 60.0{lab=CMP_ON}
C {devices/lab_pin.sym} 340.0 60.0 0 0  {name=l1 sig_type=std_logic lab=CMP_ON }
N 340.0 80.0 380.0 80.0{lab=EN}
C {devices/lab_pin.sym} 340.0 80.0 0 0  {name=l2 sig_type=std_logic lab=EN }
N 340.0 100.0 380.0 100.0{lab=RST_N}
C {devices/lab_pin.sym} 340.0 100.0 0 0  {name=l3 sig_type=std_logic lab=RST_N }
N 340.0 120.0 380.0 120.0{lab=ENO}
C {devices/lab_pin.sym} 340.0 120.0 0 0  {name=l4 sig_type=std_logic lab=ENO }
N 340.0 140.0 380.0 140.0{lab=CHL_OP}
C {devices/lab_pin.sym} 340.0 140.0 0 0  {name=l5 sig_type=std_logic lab=CHL_OP }
N 340.0 160.0 380.0 160.0{lab=CHL_ON}
C {devices/lab_pin.sym} 340.0 160.0 0 0  {name=l6 sig_type=std_logic lab=CHL_ON }
N 340.0 180.0 380.0 180.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 180.0 0 0  {name=l7 sig_type=std_logic lab=AVDD }
N 340.0 200.0 380.0 200.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 200.0 0 0  {name=l8 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SWX4_CV.sym} 400 240 0 0 {name=XA2}
N 340.0 240.0 380.0 240.0{lab=CHL_ON}
C {devices/lab_pin.sym} 340.0 240.0 0 0  {name=l9 sig_type=std_logic lab=CHL_ON }
N 340.0 260.0 380.0 260.0{lab=CN1}
C {devices/lab_pin.sym} 340.0 260.0 0 0  {name=l10 sig_type=std_logic lab=CN1 }
N 340.0 280.0 380.0 280.0{lab=VREF}
C {devices/lab_pin.sym} 340.0 280.0 0 0  {name=l11 sig_type=std_logic lab=VREF }
N 340.0 300.0 380.0 300.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 300.0 0 0  {name=l12 sig_type=std_logic lab=AVSS }
N 340.0 320.0 380.0 320.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 320.0 0 0  {name=l13 sig_type=std_logic lab=AVDD }
N 340.0 340.0 380.0 340.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 340.0 0 0  {name=l14 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SWX4_CV.sym} 400 380 0 0 {name=XA3}
N 340.0 380.0 380.0 380.0{lab=CN1}
C {devices/lab_pin.sym} 340.0 380.0 0 0  {name=l15 sig_type=std_logic lab=CN1 }
N 340.0 400.0 380.0 400.0{lab=CP1}
C {devices/lab_pin.sym} 340.0 400.0 0 0  {name=l16 sig_type=std_logic lab=CP1 }
N 340.0 420.0 380.0 420.0{lab=VREF}
C {devices/lab_pin.sym} 340.0 420.0 0 0  {name=l17 sig_type=std_logic lab=VREF }
N 340.0 440.0 380.0 440.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 440.0 0 0  {name=l18 sig_type=std_logic lab=AVSS }
N 340.0 460.0 380.0 460.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 460.0 0 0  {name=l19 sig_type=std_logic lab=AVDD }
N 340.0 480.0 380.0 480.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 480.0 0 0  {name=l20 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SWX4_CV.sym} 400 520 0 0 {name=XA4}
N 340.0 520.0 380.0 520.0{lab=CHL_OP}
C {devices/lab_pin.sym} 340.0 520.0 0 0  {name=l21 sig_type=std_logic lab=CHL_OP }
N 340.0 540.0 380.0 540.0{lab=CP0}
C {devices/lab_pin.sym} 340.0 540.0 0 0  {name=l22 sig_type=std_logic lab=CP0 }
N 340.0 560.0 380.0 560.0{lab=VREF}
C {devices/lab_pin.sym} 340.0 560.0 0 0  {name=l23 sig_type=std_logic lab=VREF }
N 340.0 580.0 380.0 580.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 580.0 0 0  {name=l24 sig_type=std_logic lab=AVSS }
N 340.0 600.0 380.0 600.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 600.0 0 0  {name=l25 sig_type=std_logic lab=AVDD }
N 340.0 620.0 380.0 620.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 620.0 0 0  {name=l26 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SWX4_CV.sym} 400 660 0 0 {name=XA5}
N 340.0 660.0 380.0 660.0{lab=CP0}
C {devices/lab_pin.sym} 340.0 660.0 0 0  {name=l27 sig_type=std_logic lab=CP0 }
N 340.0 680.0 380.0 680.0{lab=CN0}
C {devices/lab_pin.sym} 340.0 680.0 0 0  {name=l28 sig_type=std_logic lab=CN0 }
N 340.0 700.0 380.0 700.0{lab=VREF}
C {devices/lab_pin.sym} 340.0 700.0 0 0  {name=l29 sig_type=std_logic lab=VREF }
N 340.0 720.0 380.0 720.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 720.0 0 0  {name=l30 sig_type=std_logic lab=AVSS }
N 340.0 740.0 380.0 740.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 740.0 0 0  {name=l31 sig_type=std_logic lab=AVDD }
N 340.0 760.0 380.0 760.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 760.0 0 0  {name=l32 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SARCEX1_CV.sym} 400 800 0 0 {name=XA6}
N 340.0 800.0 380.0 800.0{lab=CN0}
C {devices/lab_pin.sym} 340.0 800.0 0 0  {name=l33 sig_type=std_logic lab=CN0 }
N 340.0 820.0 380.0 820.0{lab=CP1}
C {devices/lab_pin.sym} 340.0 820.0 0 0  {name=l34 sig_type=std_logic lab=CP1 }
N 340.0 840.0 380.0 840.0{lab=CE}
C {devices/lab_pin.sym} 340.0 840.0 0 0  {name=l35 sig_type=std_logic lab=CE }
N 340.0 860.0 380.0 860.0{lab=CKS}
C {devices/lab_pin.sym} 340.0 860.0 0 0  {name=l36 sig_type=std_logic lab=CKS }
N 340.0 880.0 380.0 880.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 880.0 0 0  {name=l37 sig_type=std_logic lab=AVDD }
N 340.0 900.0 380.0 900.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 900.0 0 0  {name=l38 sig_type=std_logic lab=AVSS }
N 340.0 920.0 380.0 920.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 920.0 0 0  {name=l39 sig_type=std_logic lab=AVDD }
N 340.0 940.0 380.0 940.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 940.0 0 0  {name=l40 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/IVX1_CV.sym} 400 980 0 0 {name=XA7}
N 360.0 980.0 400.0 980.0{lab=ENO}
C {devices/lab_pin.sym} 360.0 980.0 0 0  {name=l41 sig_type=std_logic lab=ENO }
N 440.0 980.0 480.0 980.0{lab=ENO_N}
C {devices/lab_pin.sym} 440.0 980.0 0 0  {name=l42 sig_type=std_logic lab=ENO_N }
N 410.0 940.0 450.0 940.0{lab=AVDD}
C {devices/lab_pin.sym} 410.0 940.0 0 0  {name=l43 sig_type=std_logic lab=AVDD }
N 410.0 1020.0 450.0 1020.0{lab=AVSS}
C {devices/lab_pin.sym} 410.0 1020.0 0 0  {name=l44 sig_type=std_logic lab=AVSS }
N 390.0 940.0 430.0 940.0{lab=AVDD}
C {devices/lab_pin.sym} 390.0 940.0 0 0  {name=l45 sig_type=std_logic lab=AVDD }
N 390.0 1020.0 430.0 1020.0{lab=AVSS}
C {devices/lab_pin.sym} 390.0 1020.0 0 0  {name=l46 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/IVX1_CV.sym} 800 0 0 0 {name=XA8}
N 760.0 0.0 800.0 0.0{lab=ENO_N}
C {devices/lab_pin.sym} 760.0 0.0 0 0  {name=l47 sig_type=std_logic lab=ENO_N }
N 840.0 0.0 880.0 0.0{lab=DONE}
C {devices/lab_pin.sym} 840.0 0.0 0 0  {name=l48 sig_type=std_logic lab=DONE }
N 810.0 -40.0 850.0 -40.0{lab=AVDD}
C {devices/lab_pin.sym} 810.0 -40.0 0 0  {name=l49 sig_type=std_logic lab=AVDD }
N 810.0 40.0 850.0 40.0{lab=AVSS}
C {devices/lab_pin.sym} 810.0 40.0 0 0  {name=l50 sig_type=std_logic lab=AVSS }
N 790.0 -40.0 830.0 -40.0{lab=AVDD}
C {devices/lab_pin.sym} 790.0 -40.0 0 0  {name=l51 sig_type=std_logic lab=AVDD }
N 790.0 40.0 830.0 40.0{lab=AVSS}
C {devices/lab_pin.sym} 790.0 40.0 0 0  {name=l52 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/NDX1_CV.sym} 800 100 0 0 {name=XA9}
N 740.0 100.0 780.0 100.0{lab=ENO_N}
C {devices/lab_pin.sym} 740.0 100.0 0 0  {name=l53 sig_type=std_logic lab=ENO_N }
N 740.0 120.0 780.0 120.0{lab=CE}
C {devices/lab_pin.sym} 740.0 120.0 0 0  {name=l54 sig_type=std_logic lab=CE }
N 740.0 140.0 780.0 140.0{lab=CE1}
C {devices/lab_pin.sym} 740.0 140.0 0 0  {name=l55 sig_type=std_logic lab=CE1 }
N 740.0 160.0 780.0 160.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 160.0 0 0  {name=l56 sig_type=std_logic lab=AVDD }
N 740.0 180.0 780.0 180.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 180.0 0 0  {name=l57 sig_type=std_logic lab=AVSS }
N 740.0 200.0 780.0 200.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 200.0 0 0  {name=l58 sig_type=std_logic lab=AVDD }
N 740.0 220.0 780.0 220.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 220.0 0 0  {name=l59 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/IVX1_CV.sym} 800 260 0 0 {name=XA10}
N 760.0 260.0 800.0 260.0{lab=CE1}
C {devices/lab_pin.sym} 760.0 260.0 0 0  {name=l60 sig_type=std_logic lab=CE1 }
N 840.0 260.0 880.0 260.0{lab=CE1_N}
C {devices/lab_pin.sym} 840.0 260.0 0 0  {name=l61 sig_type=std_logic lab=CE1_N }
N 810.0 220.0 850.0 220.0{lab=AVDD}
C {devices/lab_pin.sym} 810.0 220.0 0 0  {name=l62 sig_type=std_logic lab=AVDD }
N 810.0 300.0 850.0 300.0{lab=AVSS}
C {devices/lab_pin.sym} 810.0 300.0 0 0  {name=l63 sig_type=std_logic lab=AVSS }
N 790.0 220.0 830.0 220.0{lab=AVDD}
C {devices/lab_pin.sym} 790.0 220.0 0 0  {name=l64 sig_type=std_logic lab=AVDD }
N 790.0 300.0 830.0 300.0{lab=AVSS}
C {devices/lab_pin.sym} 790.0 300.0 0 0  {name=l65 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/NRX1_CV.sym} 800 360 0 0 {name=XA11}
N 740.0 360.0 780.0 360.0{lab=CE1_N}
C {devices/lab_pin.sym} 740.0 360.0 0 0  {name=l66 sig_type=std_logic lab=CE1_N }
N 740.0 380.0 780.0 380.0{lab=CEIN}
C {devices/lab_pin.sym} 740.0 380.0 0 0  {name=l67 sig_type=std_logic lab=CEIN }
N 740.0 400.0 780.0 400.0{lab=CEO1}
C {devices/lab_pin.sym} 740.0 400.0 0 0  {name=l68 sig_type=std_logic lab=CEO1 }
N 740.0 420.0 780.0 420.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 420.0 0 0  {name=l69 sig_type=std_logic lab=AVDD }
N 740.0 440.0 780.0 440.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 440.0 0 0  {name=l70 sig_type=std_logic lab=AVSS }
N 740.0 460.0 780.0 460.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 460.0 0 0  {name=l71 sig_type=std_logic lab=AVDD }
N 740.0 480.0 780.0 480.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 480.0 0 0  {name=l72 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/IVX1_CV.sym} 800 520 0 0 {name=XA12}
N 760.0 520.0 800.0 520.0{lab=CEO1}
C {devices/lab_pin.sym} 760.0 520.0 0 0  {name=l73 sig_type=std_logic lab=CEO1 }
N 840.0 520.0 880.0 520.0{lab=CEO}
C {devices/lab_pin.sym} 840.0 520.0 0 0  {name=l74 sig_type=std_logic lab=CEO }
N 810.0 480.0 850.0 480.0{lab=AVDD}
C {devices/lab_pin.sym} 810.0 480.0 0 0  {name=l75 sig_type=std_logic lab=AVDD }
N 810.0 560.0 850.0 560.0{lab=AVSS}
C {devices/lab_pin.sym} 810.0 560.0 0 0  {name=l76 sig_type=std_logic lab=AVSS }
N 790.0 480.0 830.0 480.0{lab=AVDD}
C {devices/lab_pin.sym} 790.0 480.0 0 0  {name=l77 sig_type=std_logic lab=AVDD }
N 790.0 560.0 830.0 560.0{lab=AVSS}
C {devices/lab_pin.sym} 790.0 560.0 0 0  {name=l78 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/TAPCELLB_CV.sym} 800 620 0 0 {name=XA13}
N 740.0 620.0 780.0 620.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 620.0 0 0  {name=l79 sig_type=std_logic lab=AVDD }
N 740.0 640.0 780.0 640.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 640.0 0 0  {name=l80 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/DMY_CV.sym} 800 680 0 0 {name=XA14}
