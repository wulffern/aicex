v {xschem version=3.0.0 file_version=1.2 }
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=CPI}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=CNI}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=CPO}
C {devices/iopin.sym} 0 60 0 0{name=p3 lab=CNO}
C {devices/iopin.sym} 0 80 0 0{name=p4 lab=CK_CMP}
C {devices/iopin.sym} 0 100 0 0{name=p5 lab=CK_SAMPLE}
C {devices/iopin.sym} 0 120 0 0{name=p6 lab=DONE}
C {devices/iopin.sym} 0 140 0 0{name=p7 lab=AVDD}
C {devices/iopin.sym} 0 160 0 0{name=p8 lab=AVSS}
C {SUN_SAR9B_SK130NM/DMY_CV.sym} 400 0 0 0 {name=XA0a}
C {SUN_SAR9B_SK130NM/TAPCELLB_CV.sym} 400 40 0 0 {name=XA0}
N 340.0 40.0 380.0 40.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 40.0 0 0  {name=l0 sig_type=std_logic lab=AVDD }
N 340.0 60.0 380.0 60.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 60.0 0 0  {name=l1 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SARKICKHX1_CV.sym} 400 100 0 0 {name=XA1}
N 340.0 100.0 380.0 100.0{lab=CPI}
C {devices/lab_pin.sym} 340.0 100.0 0 0  {name=l2 sig_type=std_logic lab=CPI }
N 340.0 120.0 380.0 120.0{lab=CK_B}
C {devices/lab_pin.sym} 340.0 120.0 0 0  {name=l3 sig_type=std_logic lab=CK_B }
N 340.0 140.0 380.0 140.0{lab=CK_N}
C {devices/lab_pin.sym} 340.0 140.0 0 0  {name=l4 sig_type=std_logic lab=CK_N }
N 340.0 160.0 380.0 160.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 160.0 0 0  {name=l5 sig_type=std_logic lab=AVDD }
N 340.0 180.0 380.0 180.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 180.0 0 0  {name=l6 sig_type=std_logic lab=AVSS }
N 340.0 200.0 380.0 200.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 200.0 0 0  {name=l7 sig_type=std_logic lab=AVDD }
N 340.0 220.0 380.0 220.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 220.0 0 0  {name=l8 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SARCMPHX1_CV.sym} 400 260 0 0 {name=XA2}
N 340.0 260.0 380.0 260.0{lab=CPI}
C {devices/lab_pin.sym} 340.0 260.0 0 0  {name=l9 sig_type=std_logic lab=CPI }
N 340.0 280.0 380.0 280.0{lab=CK_B}
C {devices/lab_pin.sym} 340.0 280.0 0 0  {name=l10 sig_type=std_logic lab=CK_B }
N 340.0 300.0 380.0 300.0{lab=CNO_I}
C {devices/lab_pin.sym} 340.0 300.0 0 0  {name=l11 sig_type=std_logic lab=CNO_I }
N 340.0 320.0 380.0 320.0{lab=CPO_I}
C {devices/lab_pin.sym} 340.0 320.0 0 0  {name=l12 sig_type=std_logic lab=CPO_I }
N 340.0 340.0 380.0 340.0{lab=N1}
C {devices/lab_pin.sym} 340.0 340.0 0 0  {name=l13 sig_type=std_logic lab=N1 }
N 340.0 360.0 380.0 360.0{lab=NC1}
C {devices/lab_pin.sym} 340.0 360.0 0 0  {name=l14 sig_type=std_logic lab=NC1 }
N 340.0 380.0 380.0 380.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 380.0 0 0  {name=l15 sig_type=std_logic lab=AVDD }
N 340.0 400.0 380.0 400.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 400.0 0 0  {name=l16 sig_type=std_logic lab=AVSS }
N 340.0 420.0 380.0 420.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 420.0 0 0  {name=l17 sig_type=std_logic lab=AVDD }
N 340.0 440.0 380.0 440.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 440.0 0 0  {name=l18 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/IVX4_CV.sym} 400 480 0 0 {name=XA2a}
N 360.0 480.0 400.0 480.0{lab=CPO_I}
C {devices/lab_pin.sym} 360.0 480.0 0 0  {name=l19 sig_type=std_logic lab=CPO_I }
N 440.0 480.0 480.0 480.0{lab=CPO}
C {devices/lab_pin.sym} 440.0 480.0 0 0  {name=l20 sig_type=std_logic lab=CPO }
N 410.0 440.0 450.0 440.0{lab=AVDD}
C {devices/lab_pin.sym} 410.0 440.0 0 0  {name=l21 sig_type=std_logic lab=AVDD }
N 410.0 520.0 450.0 520.0{lab=AVSS}
C {devices/lab_pin.sym} 410.0 520.0 0 0  {name=l22 sig_type=std_logic lab=AVSS }
N 390.0 440.0 430.0 440.0{lab=AVDD}
C {devices/lab_pin.sym} 390.0 440.0 0 0  {name=l23 sig_type=std_logic lab=AVDD }
N 390.0 520.0 430.0 520.0{lab=AVSS}
C {devices/lab_pin.sym} 390.0 520.0 0 0  {name=l24 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/IVX4_CV.sym} 400 580 0 0 {name=XA3a}
N 360.0 580.0 400.0 580.0{lab=CNO_I}
C {devices/lab_pin.sym} 360.0 580.0 0 0  {name=l25 sig_type=std_logic lab=CNO_I }
N 440.0 580.0 480.0 580.0{lab=CNO}
C {devices/lab_pin.sym} 440.0 580.0 0 0  {name=l26 sig_type=std_logic lab=CNO }
N 410.0 540.0 450.0 540.0{lab=AVDD}
C {devices/lab_pin.sym} 410.0 540.0 0 0  {name=l27 sig_type=std_logic lab=AVDD }
N 410.0 620.0 450.0 620.0{lab=AVSS}
C {devices/lab_pin.sym} 410.0 620.0 0 0  {name=l28 sig_type=std_logic lab=AVSS }
N 390.0 540.0 430.0 540.0{lab=AVDD}
C {devices/lab_pin.sym} 390.0 540.0 0 0  {name=l29 sig_type=std_logic lab=AVDD }
N 390.0 620.0 430.0 620.0{lab=AVSS}
C {devices/lab_pin.sym} 390.0 620.0 0 0  {name=l30 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SARCMPHX1_CV.sym} 400 680 0 0 {name=XA3}
N 340.0 680.0 380.0 680.0{lab=CNI}
C {devices/lab_pin.sym} 340.0 680.0 0 0  {name=l31 sig_type=std_logic lab=CNI }
N 340.0 700.0 380.0 700.0{lab=CK_B}
C {devices/lab_pin.sym} 340.0 700.0 0 0  {name=l32 sig_type=std_logic lab=CK_B }
N 340.0 720.0 380.0 720.0{lab=CPO_I}
C {devices/lab_pin.sym} 340.0 720.0 0 0  {name=l33 sig_type=std_logic lab=CPO_I }
N 340.0 740.0 380.0 740.0{lab=CNO_I}
C {devices/lab_pin.sym} 340.0 740.0 0 0  {name=l34 sig_type=std_logic lab=CNO_I }
N 340.0 760.0 380.0 760.0{lab=N1}
C {devices/lab_pin.sym} 340.0 760.0 0 0  {name=l35 sig_type=std_logic lab=N1 }
N 340.0 780.0 380.0 780.0{lab=NC2}
C {devices/lab_pin.sym} 340.0 780.0 0 0  {name=l36 sig_type=std_logic lab=NC2 }
N 340.0 800.0 380.0 800.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 800.0 0 0  {name=l37 sig_type=std_logic lab=AVDD }
N 340.0 820.0 380.0 820.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 820.0 0 0  {name=l38 sig_type=std_logic lab=AVSS }
N 340.0 840.0 380.0 840.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 840.0 0 0  {name=l39 sig_type=std_logic lab=AVDD }
N 340.0 860.0 380.0 860.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 860.0 0 0  {name=l40 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SARKICKHX1_CV.sym} 400 900 0 0 {name=XA4}
N 340.0 900.0 380.0 900.0{lab=CNI}
C {devices/lab_pin.sym} 340.0 900.0 0 0  {name=l41 sig_type=std_logic lab=CNI }
N 340.0 920.0 380.0 920.0{lab=CK_B}
C {devices/lab_pin.sym} 340.0 920.0 0 0  {name=l42 sig_type=std_logic lab=CK_B }
N 340.0 940.0 380.0 940.0{lab=CK_N}
C {devices/lab_pin.sym} 340.0 940.0 0 0  {name=l43 sig_type=std_logic lab=CK_N }
N 340.0 960.0 380.0 960.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 960.0 0 0  {name=l44 sig_type=std_logic lab=AVDD }
N 340.0 980.0 380.0 980.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 980.0 0 0  {name=l45 sig_type=std_logic lab=AVSS }
N 340.0 1000.0 380.0 1000.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 1000.0 0 0  {name=l46 sig_type=std_logic lab=AVDD }
N 340.0 1020.0 380.0 1020.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 1020.0 0 0  {name=l47 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/IVX1_CV.sym} 800 0 0 0 {name=XA9}
N 760.0 0.0 800.0 0.0{lab=CK_N}
C {devices/lab_pin.sym} 760.0 0.0 0 0  {name=l48 sig_type=std_logic lab=CK_N }
N 840.0 0.0 880.0 0.0{lab=CK_B}
C {devices/lab_pin.sym} 840.0 0.0 0 0  {name=l49 sig_type=std_logic lab=CK_B }
N 810.0 -40.0 850.0 -40.0{lab=AVDD}
C {devices/lab_pin.sym} 810.0 -40.0 0 0  {name=l50 sig_type=std_logic lab=AVDD }
N 810.0 40.0 850.0 40.0{lab=AVSS}
C {devices/lab_pin.sym} 810.0 40.0 0 0  {name=l51 sig_type=std_logic lab=AVSS }
N 790.0 -40.0 830.0 -40.0{lab=AVDD}
C {devices/lab_pin.sym} 790.0 -40.0 0 0  {name=l52 sig_type=std_logic lab=AVDD }
N 790.0 40.0 830.0 40.0{lab=AVSS}
C {devices/lab_pin.sym} 790.0 40.0 0 0  {name=l53 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/NDX1_CV.sym} 800 100 0 0 {name=XA10}
N 740.0 100.0 780.0 100.0{lab=DONE_N}
C {devices/lab_pin.sym} 740.0 100.0 0 0  {name=l54 sig_type=std_logic lab=DONE_N }
N 740.0 120.0 780.0 120.0{lab=CK_A}
C {devices/lab_pin.sym} 740.0 120.0 0 0  {name=l55 sig_type=std_logic lab=CK_A }
N 740.0 140.0 780.0 140.0{lab=CK_N}
C {devices/lab_pin.sym} 740.0 140.0 0 0  {name=l56 sig_type=std_logic lab=CK_N }
N 740.0 160.0 780.0 160.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 160.0 0 0  {name=l57 sig_type=std_logic lab=AVDD }
N 740.0 180.0 780.0 180.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 180.0 0 0  {name=l58 sig_type=std_logic lab=AVSS }
N 740.0 200.0 780.0 200.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 200.0 0 0  {name=l59 sig_type=std_logic lab=AVDD }
N 740.0 220.0 780.0 220.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 220.0 0 0  {name=l60 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/NRX1_CV.sym} 800 260 0 0 {name=XA11}
N 740.0 260.0 780.0 260.0{lab=CK_SAMPLE}
C {devices/lab_pin.sym} 740.0 260.0 0 0  {name=l61 sig_type=std_logic lab=CK_SAMPLE }
N 740.0 280.0 780.0 280.0{lab=DONE}
C {devices/lab_pin.sym} 740.0 280.0 0 0  {name=l62 sig_type=std_logic lab=DONE }
N 740.0 300.0 780.0 300.0{lab=DONE_N}
C {devices/lab_pin.sym} 740.0 300.0 0 0  {name=l63 sig_type=std_logic lab=DONE_N }
N 740.0 320.0 780.0 320.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 320.0 0 0  {name=l64 sig_type=std_logic lab=AVDD }
N 740.0 340.0 780.0 340.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 340.0 0 0  {name=l65 sig_type=std_logic lab=AVSS }
N 740.0 360.0 780.0 360.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 360.0 0 0  {name=l66 sig_type=std_logic lab=AVDD }
N 740.0 380.0 780.0 380.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 380.0 0 0  {name=l67 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/IVX1_CV.sym} 800 420 0 0 {name=XA12}
N 760.0 420.0 800.0 420.0{lab=CK_CMP}
C {devices/lab_pin.sym} 760.0 420.0 0 0  {name=l68 sig_type=std_logic lab=CK_CMP }
N 840.0 420.0 880.0 420.0{lab=CK_A}
C {devices/lab_pin.sym} 840.0 420.0 0 0  {name=l69 sig_type=std_logic lab=CK_A }
N 810.0 380.0 850.0 380.0{lab=AVDD}
C {devices/lab_pin.sym} 810.0 380.0 0 0  {name=l70 sig_type=std_logic lab=AVDD }
N 810.0 460.0 850.0 460.0{lab=AVSS}
C {devices/lab_pin.sym} 810.0 460.0 0 0  {name=l71 sig_type=std_logic lab=AVSS }
N 790.0 380.0 830.0 380.0{lab=AVDD}
C {devices/lab_pin.sym} 790.0 380.0 0 0  {name=l72 sig_type=std_logic lab=AVDD }
N 790.0 460.0 830.0 460.0{lab=AVSS}
C {devices/lab_pin.sym} 790.0 460.0 0 0  {name=l73 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/TAPCELLB_CV.sym} 800 520 0 0 {name=XA13}
N 740.0 520.0 780.0 520.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 520.0 0 0  {name=l74 sig_type=std_logic lab=AVDD }
N 740.0 540.0 780.0 540.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 540.0 0 0  {name=l75 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/DMY_CV.sym} 800 580 0 0 {name=XA14}
