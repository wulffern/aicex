v {xschem version=3.0.0 file_version=1.2 }
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=VI}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=CK}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=CKN}
C {devices/iopin.sym} 0 60 0 0{name=p3 lab=TIE_L}
C {devices/iopin.sym} 0 80 0 0{name=p4 lab=VO1}
C {devices/iopin.sym} 0 100 0 0{name=p5 lab=VO2}
C {devices/iopin.sym} 0 120 0 0{name=p6 lab=AVDD}
C {devices/iopin.sym} 0 140 0 0{name=p7 lab=AVSS}
C {SUN_SAR9B_SK130NM/NCHDLR.sym} 400 0 0 0 {name=M1}
N 400.0 -30.0 440.0 -30.0{lab=VI}
C {devices/lab_pin.sym} 400.0 -30.0 0 0  {name=l0 sig_type=std_logic lab=VI }
N 360.0 0.0 400.0 0.0{lab=GN}
C {devices/lab_pin.sym} 360.0 0.0 0 0  {name=l1 sig_type=std_logic lab=GN }
N 400.0 30.0 440.0 30.0{lab=VO1}
C {devices/lab_pin.sym} 400.0 30.0 0 0  {name=l2 sig_type=std_logic lab=VO1 }
N 520.0 0.0 440.0 0.0{lab=AVSS}
C {devices/lab_pin.sym} 520.0 0.0 0 0  {name=l3 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/NCHDLR.sym} 400 100 0 0 {name=M2}
N 400.0 70.0 440.0 70.0{lab=VI}
C {devices/lab_pin.sym} 400.0 70.0 0 0  {name=l4 sig_type=std_logic lab=VI }
N 360.0 100.0 400.0 100.0{lab=GN}
C {devices/lab_pin.sym} 360.0 100.0 0 0  {name=l5 sig_type=std_logic lab=GN }
N 400.0 130.0 440.0 130.0{lab=VO1}
C {devices/lab_pin.sym} 400.0 130.0 0 0  {name=l6 sig_type=std_logic lab=VO1 }
N 520.0 100.0 440.0 100.0{lab=AVSS}
C {devices/lab_pin.sym} 520.0 100.0 0 0  {name=l7 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/NCHDLR.sym} 400 200 0 0 {name=M3}
N 400.0 170.0 440.0 170.0{lab=VI}
C {devices/lab_pin.sym} 400.0 170.0 0 0  {name=l8 sig_type=std_logic lab=VI }
N 360.0 200.0 400.0 200.0{lab=GN}
C {devices/lab_pin.sym} 360.0 200.0 0 0  {name=l9 sig_type=std_logic lab=GN }
N 400.0 230.0 440.0 230.0{lab=VO1}
C {devices/lab_pin.sym} 400.0 230.0 0 0  {name=l10 sig_type=std_logic lab=VO1 }
N 520.0 200.0 440.0 200.0{lab=AVSS}
C {devices/lab_pin.sym} 520.0 200.0 0 0  {name=l11 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/NCHDLR.sym} 400 300 0 0 {name=M4}
N 400.0 270.0 440.0 270.0{lab=VI}
C {devices/lab_pin.sym} 400.0 270.0 0 0  {name=l12 sig_type=std_logic lab=VI }
N 360.0 300.0 400.0 300.0{lab=GN}
C {devices/lab_pin.sym} 360.0 300.0 0 0  {name=l13 sig_type=std_logic lab=GN }
N 400.0 330.0 440.0 330.0{lab=VO1}
C {devices/lab_pin.sym} 400.0 330.0 0 0  {name=l14 sig_type=std_logic lab=VO1 }
N 520.0 300.0 440.0 300.0{lab=AVSS}
C {devices/lab_pin.sym} 520.0 300.0 0 0  {name=l15 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/NCHDLR.sym} 400 400 0 0 {name=M5}
N 400.0 370.0 440.0 370.0{lab=VI}
C {devices/lab_pin.sym} 400.0 370.0 0 0  {name=l16 sig_type=std_logic lab=VI }
N 360.0 400.0 400.0 400.0{lab=TIE_L}
C {devices/lab_pin.sym} 360.0 400.0 0 0  {name=l17 sig_type=std_logic lab=TIE_L }
N 400.0 430.0 440.0 430.0{lab=VO2}
C {devices/lab_pin.sym} 400.0 430.0 0 0  {name=l18 sig_type=std_logic lab=VO2 }
N 520.0 400.0 440.0 400.0{lab=AVSS}
C {devices/lab_pin.sym} 520.0 400.0 0 0  {name=l19 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/NCHDLR.sym} 400 500 0 0 {name=M6}
N 400.0 470.0 440.0 470.0{lab=VI}
C {devices/lab_pin.sym} 400.0 470.0 0 0  {name=l20 sig_type=std_logic lab=VI }
N 360.0 500.0 400.0 500.0{lab=TIE_L}
C {devices/lab_pin.sym} 360.0 500.0 0 0  {name=l21 sig_type=std_logic lab=TIE_L }
N 400.0 530.0 440.0 530.0{lab=VO2}
C {devices/lab_pin.sym} 400.0 530.0 0 0  {name=l22 sig_type=std_logic lab=VO2 }
N 520.0 500.0 440.0 500.0{lab=AVSS}
C {devices/lab_pin.sym} 520.0 500.0 0 0  {name=l23 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/NCHDLR.sym} 400 600 0 0 {name=M7}
N 400.0 570.0 440.0 570.0{lab=VI}
C {devices/lab_pin.sym} 400.0 570.0 0 0  {name=l24 sig_type=std_logic lab=VI }
N 360.0 600.0 400.0 600.0{lab=TIE_L}
C {devices/lab_pin.sym} 360.0 600.0 0 0  {name=l25 sig_type=std_logic lab=TIE_L }
N 400.0 630.0 440.0 630.0{lab=VO2}
C {devices/lab_pin.sym} 400.0 630.0 0 0  {name=l26 sig_type=std_logic lab=VO2 }
N 520.0 600.0 440.0 600.0{lab=AVSS}
C {devices/lab_pin.sym} 520.0 600.0 0 0  {name=l27 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/NCHDLR.sym} 400 700 0 0 {name=M8}
N 400.0 670.0 440.0 670.0{lab=VI}
C {devices/lab_pin.sym} 400.0 670.0 0 0  {name=l28 sig_type=std_logic lab=VI }
N 360.0 700.0 400.0 700.0{lab=TIE_L}
C {devices/lab_pin.sym} 360.0 700.0 0 0  {name=l29 sig_type=std_logic lab=TIE_L }
N 400.0 730.0 440.0 730.0{lab=VO2}
C {devices/lab_pin.sym} 400.0 730.0 0 0  {name=l30 sig_type=std_logic lab=VO2 }
N 520.0 700.0 440.0 700.0{lab=AVSS}
C {devices/lab_pin.sym} 520.0 700.0 0 0  {name=l31 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/TAPCELLB_CV.sym} 400 800 0 0 {name=XA5b}
N 340.0 800.0 380.0 800.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 800.0 0 0  {name=l32 sig_type=std_logic lab=AVDD }
N 340.0 820.0 380.0 820.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 820.0 0 0  {name=l33 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/IVX1_CV.sym} 400 860 0 0 {name=XA0}
N 360.0 860.0 400.0 860.0{lab=CK}
C {devices/lab_pin.sym} 360.0 860.0 0 0  {name=l34 sig_type=std_logic lab=CK }
N 440.0 860.0 480.0 860.0{lab=CKN}
C {devices/lab_pin.sym} 440.0 860.0 0 0  {name=l35 sig_type=std_logic lab=CKN }
N 410.0 820.0 450.0 820.0{lab=AVDD}
C {devices/lab_pin.sym} 410.0 820.0 0 0  {name=l36 sig_type=std_logic lab=AVDD }
N 410.0 900.0 450.0 900.0{lab=AVSS}
C {devices/lab_pin.sym} 410.0 900.0 0 0  {name=l37 sig_type=std_logic lab=AVSS }
N 390.0 820.0 430.0 820.0{lab=AVDD}
C {devices/lab_pin.sym} 390.0 820.0 0 0  {name=l38 sig_type=std_logic lab=AVDD }
N 390.0 900.0 430.0 900.0{lab=AVSS}
C {devices/lab_pin.sym} 390.0 900.0 0 0  {name=l39 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/TGPD_CV.sym} 400 960 0 0 {name=XA3}
N 340.0 960.0 380.0 960.0{lab=CKN}
C {devices/lab_pin.sym} 340.0 960.0 0 0  {name=l40 sig_type=std_logic lab=CKN }
N 340.0 980.0 380.0 980.0{lab=VI}
C {devices/lab_pin.sym} 340.0 980.0 0 0  {name=l41 sig_type=std_logic lab=VI }
N 340.0 1000.0 380.0 1000.0{lab=VS}
C {devices/lab_pin.sym} 340.0 1000.0 0 0  {name=l42 sig_type=std_logic lab=VS }
N 340.0 1020.0 380.0 1020.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 1020.0 0 0  {name=l43 sig_type=std_logic lab=AVDD }
N 340.0 1040.0 380.0 1040.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 1040.0 0 0  {name=l44 sig_type=std_logic lab=AVSS }
N 340.0 1060.0 380.0 1060.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 1060.0 0 0  {name=l45 sig_type=std_logic lab=AVDD }
N 340.0 1080.0 380.0 1080.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 1080.0 0 0  {name=l46 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/SARBSSWCTRL_CV.sym} 800 0 0 0 {name=XA4}
N 740.0 0.0 780.0 0.0{lab=CKN}
C {devices/lab_pin.sym} 740.0 0.0 0 0  {name=l47 sig_type=std_logic lab=CKN }
N 740.0 20.0 780.0 20.0{lab=GN}
C {devices/lab_pin.sym} 740.0 20.0 0 0  {name=l48 sig_type=std_logic lab=GN }
N 740.0 40.0 780.0 40.0{lab=GNG}
C {devices/lab_pin.sym} 740.0 40.0 0 0  {name=l49 sig_type=std_logic lab=GNG }
N 740.0 60.0 780.0 60.0{lab=TIE_H}
C {devices/lab_pin.sym} 740.0 60.0 0 0  {name=l50 sig_type=std_logic lab=TIE_H }
N 740.0 80.0 780.0 80.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 80.0 0 0  {name=l51 sig_type=std_logic lab=AVDD }
N 740.0 100.0 780.0 100.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 100.0 0 0  {name=l52 sig_type=std_logic lab=AVSS }
N 740.0 120.0 780.0 120.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 120.0 0 0  {name=l53 sig_type=std_logic lab=AVDD }
N 740.0 140.0 780.0 140.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 140.0 0 0  {name=l54 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/TIEH_CV.sym} 800 180 0 0 {name=XA1}
N 740.0 180.0 780.0 180.0{lab=TIE_H}
C {devices/lab_pin.sym} 740.0 180.0 0 0  {name=l55 sig_type=std_logic lab=TIE_H }
N 740.0 200.0 780.0 200.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 200.0 0 0  {name=l56 sig_type=std_logic lab=AVDD }
N 740.0 220.0 780.0 220.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 220.0 0 0  {name=l57 sig_type=std_logic lab=AVSS }
N 740.0 240.0 780.0 240.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 240.0 0 0  {name=l58 sig_type=std_logic lab=AVDD }
N 740.0 260.0 780.0 260.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 260.0 0 0  {name=l59 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/TAPCELLB_CV.sym} 800 300 0 0 {name=XA7}
N 740.0 300.0 780.0 300.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 300.0 0 0  {name=l60 sig_type=std_logic lab=AVDD }
N 740.0 320.0 780.0 320.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 320.0 0 0  {name=l61 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/TIEL_CV.sym} 800 360 0 0 {name=XA2}
N 740.0 360.0 780.0 360.0{lab=TIE_L}
C {devices/lab_pin.sym} 740.0 360.0 0 0  {name=l62 sig_type=std_logic lab=TIE_L }
N 740.0 380.0 780.0 380.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 380.0 0 0  {name=l63 sig_type=std_logic lab=AVDD }
N 740.0 400.0 780.0 400.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 400.0 0 0  {name=l64 sig_type=std_logic lab=AVSS }
N 740.0 420.0 780.0 420.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 420.0 0 0  {name=l65 sig_type=std_logic lab=AVDD }
N 740.0 440.0 780.0 440.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 440.0 0 0  {name=l66 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/TAPCELLB_CV.sym} 800 480 0 0 {name=XA5}
N 740.0 480.0 780.0 480.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 480.0 0 0  {name=l67 sig_type=std_logic lab=AVDD }
N 740.0 500.0 780.0 500.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 500.0 0 0  {name=l68 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SK130NM/CAP_BSSW5_CV.sym} 800 540 0 0 {name=XCAPB1}
N 740.0 540.0 780.0 540.0{lab=GNG}
C {devices/lab_pin.sym} 740.0 540.0 0 0  {name=l69 sig_type=std_logic lab=GNG }
N 740.0 560.0 780.0 560.0{lab=VS}
C {devices/lab_pin.sym} 740.0 560.0 0 0  {name=l70 sig_type=std_logic lab=VS }
