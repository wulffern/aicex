v {xschem version=3.0.0 file_version=1.2 }
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=AVDD}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=AVSS}
C {SUN_TR_SK130NM/TAPCELLB_CV.sym} 400 0 0 0 {name=XA0}
N 340.0 0.0 380.0 0.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 0.0 0 0  {name=l0 sig_type=std_logic lab=AVDD }
N 340.0 20.0 380.0 20.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 20.0 0 0  {name=l1 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/TIEH_CV.sym} 400 60 0 0 {name=XA1}
N 340.0 60.0 380.0 60.0{lab=Y1}
C {devices/lab_pin.sym} 340.0 60.0 0 0  {name=l2 sig_type=std_logic lab=Y1 }
N 340.0 80.0 380.0 80.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 80.0 0 0  {name=l3 sig_type=std_logic lab=AVDD }
N 340.0 100.0 380.0 100.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 100.0 0 0  {name=l4 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/TIEL_CV.sym} 400 140 0 0 {name=XA2}
N 340.0 140.0 380.0 140.0{lab=Y2}
C {devices/lab_pin.sym} 340.0 140.0 0 0  {name=l5 sig_type=std_logic lab=Y2 }
N 340.0 160.0 380.0 160.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 160.0 0 0  {name=l6 sig_type=std_logic lab=AVDD }
N 340.0 180.0 380.0 180.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 180.0 0 0  {name=l7 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/TAPCELLB_CV.sym} 400 220 0 0 {name=XB0}
N 340.0 220.0 380.0 220.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 220.0 0 0  {name=l8 sig_type=std_logic lab=AVDD }
N 340.0 240.0 380.0 240.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 240.0 0 0  {name=l9 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/IVX1_CV.sym} 400 280 0 0 {name=XB3}
N 360.0 280.0 400.0 280.0{lab=A3}
C {devices/lab_pin.sym} 360.0 280.0 0 0  {name=l10 sig_type=std_logic lab=A3 }
N 440.0 280.0 480.0 280.0{lab=Y3}
C {devices/lab_pin.sym} 440.0 280.0 0 0  {name=l11 sig_type=std_logic lab=Y3 }
N 390.0 240.0 430.0 240.0{lab=AVDD}
C {devices/lab_pin.sym} 390.0 240.0 0 0  {name=l12 sig_type=std_logic lab=AVDD }
N 390.0 320.0 430.0 320.0{lab=AVSS}
C {devices/lab_pin.sym} 390.0 320.0 0 0  {name=l13 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/IVX2_CV.sym} 400 380 0 0 {name=XB4}
N 360.0 380.0 400.0 380.0{lab=A4}
C {devices/lab_pin.sym} 360.0 380.0 0 0  {name=l14 sig_type=std_logic lab=A4 }
N 440.0 380.0 480.0 380.0{lab=Y4}
C {devices/lab_pin.sym} 440.0 380.0 0 0  {name=l15 sig_type=std_logic lab=Y4 }
N 390.0 340.0 430.0 340.0{lab=AVDD}
C {devices/lab_pin.sym} 390.0 340.0 0 0  {name=l16 sig_type=std_logic lab=AVDD }
N 390.0 420.0 430.0 420.0{lab=AVSS}
C {devices/lab_pin.sym} 390.0 420.0 0 0  {name=l17 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/IVX4_CV.sym} 400 480 0 0 {name=XB5}
N 360.0 480.0 400.0 480.0{lab=A5}
C {devices/lab_pin.sym} 360.0 480.0 0 0  {name=l18 sig_type=std_logic lab=A5 }
N 440.0 480.0 480.0 480.0{lab=Y5}
C {devices/lab_pin.sym} 440.0 480.0 0 0  {name=l19 sig_type=std_logic lab=Y5 }
N 390.0 440.0 430.0 440.0{lab=AVDD}
C {devices/lab_pin.sym} 390.0 440.0 0 0  {name=l20 sig_type=std_logic lab=AVDD }
N 390.0 520.0 430.0 520.0{lab=AVSS}
C {devices/lab_pin.sym} 390.0 520.0 0 0  {name=l21 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/IVX8_CV.sym} 400 580 0 0 {name=XB6}
N 360.0 580.0 400.0 580.0{lab=A6}
C {devices/lab_pin.sym} 360.0 580.0 0 0  {name=l22 sig_type=std_logic lab=A6 }
N 440.0 580.0 480.0 580.0{lab=Y6}
C {devices/lab_pin.sym} 440.0 580.0 0 0  {name=l23 sig_type=std_logic lab=Y6 }
N 390.0 540.0 430.0 540.0{lab=AVDD}
C {devices/lab_pin.sym} 390.0 540.0 0 0  {name=l24 sig_type=std_logic lab=AVDD }
N 390.0 620.0 430.0 620.0{lab=AVSS}
C {devices/lab_pin.sym} 390.0 620.0 0 0  {name=l25 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/TAPCELLB_CV.sym} 400 680 0 0 {name=XC0}
N 340.0 680.0 380.0 680.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 680.0 0 0  {name=l26 sig_type=std_logic lab=AVDD }
N 340.0 700.0 380.0 700.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 700.0 0 0  {name=l27 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/BFX1_CV.sym} 400 740 0 0 {name=XC7}
N 340.0 740.0 380.0 740.0{lab=A7}
C {devices/lab_pin.sym} 340.0 740.0 0 0  {name=l28 sig_type=std_logic lab=A7 }
N 340.0 760.0 380.0 760.0{lab=Y7}
C {devices/lab_pin.sym} 340.0 760.0 0 0  {name=l29 sig_type=std_logic lab=Y7 }
N 340.0 780.0 380.0 780.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 780.0 0 0  {name=l30 sig_type=std_logic lab=AVDD }
N 340.0 800.0 380.0 800.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 800.0 0 0  {name=l31 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/TAPCELLB_CV.sym} 400 840 0 0 {name=XD0}
N 340.0 840.0 380.0 840.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 840.0 0 0  {name=l32 sig_type=std_logic lab=AVDD }
N 340.0 860.0 380.0 860.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 860.0 0 0  {name=l33 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/NRX1_CV.sym} 400 900 0 0 {name=XD8}
N 340.0 900.0 380.0 900.0{lab=A8}
C {devices/lab_pin.sym} 340.0 900.0 0 0  {name=l34 sig_type=std_logic lab=A8 }
N 340.0 920.0 380.0 920.0{lab=B8}
C {devices/lab_pin.sym} 340.0 920.0 0 0  {name=l35 sig_type=std_logic lab=B8 }
N 340.0 940.0 380.0 940.0{lab=Y8}
C {devices/lab_pin.sym} 340.0 940.0 0 0  {name=l36 sig_type=std_logic lab=Y8 }
N 340.0 960.0 380.0 960.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 960.0 0 0  {name=l37 sig_type=std_logic lab=AVDD }
N 340.0 980.0 380.0 980.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 980.0 0 0  {name=l38 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/NDX1_CV.sym} 800 0 0 0 {name=XD9}
N 740.0 0.0 780.0 0.0{lab=A9}
C {devices/lab_pin.sym} 740.0 0.0 0 0  {name=l39 sig_type=std_logic lab=A9 }
N 740.0 20.0 780.0 20.0{lab=B9}
C {devices/lab_pin.sym} 740.0 20.0 0 0  {name=l40 sig_type=std_logic lab=B9 }
N 740.0 40.0 780.0 40.0{lab=Y9}
C {devices/lab_pin.sym} 740.0 40.0 0 0  {name=l41 sig_type=std_logic lab=Y9 }
N 740.0 60.0 780.0 60.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 60.0 0 0  {name=l42 sig_type=std_logic lab=AVDD }
N 740.0 80.0 780.0 80.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 80.0 0 0  {name=l43 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/ORX1_CV.sym} 800 120 0 0 {name=XD10}
N 740.0 120.0 780.0 120.0{lab=A10}
C {devices/lab_pin.sym} 740.0 120.0 0 0  {name=l44 sig_type=std_logic lab=A10 }
N 740.0 140.0 780.0 140.0{lab=B10}
C {devices/lab_pin.sym} 740.0 140.0 0 0  {name=l45 sig_type=std_logic lab=B10 }
N 740.0 160.0 780.0 160.0{lab=Y10}
C {devices/lab_pin.sym} 740.0 160.0 0 0  {name=l46 sig_type=std_logic lab=Y10 }
N 740.0 180.0 780.0 180.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 180.0 0 0  {name=l47 sig_type=std_logic lab=AVDD }
N 740.0 200.0 780.0 200.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 200.0 0 0  {name=l48 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/ANX1_CV.sym} 800 240 0 0 {name=XD11}
N 760.0 220.0 800.0 220.0{lab=A11}
C {devices/lab_pin.sym} 760.0 220.0 0 0  {name=l49 sig_type=std_logic lab=A11 }
N 760.0 240.0 800.0 240.0{lab=B11}
C {devices/lab_pin.sym} 760.0 240.0 0 0  {name=l50 sig_type=std_logic lab=B11 }
N 850.0 230.0 890.0 230.0{lab=Y11}
C {devices/lab_pin.sym} 850.0 230.0 0 0  {name=l51 sig_type=std_logic lab=Y11 }
N 800.0 190.0 840.0 190.0{lab=AVDD}
C {devices/lab_pin.sym} 800.0 190.0 0 0  {name=l52 sig_type=std_logic lab=AVDD }
N 800.0 270.0 840.0 270.0{lab=AVSS}
C {devices/lab_pin.sym} 800.0 270.0 0 0  {name=l53 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/TAPCELLB_CV.sym} 800 340 0 0 {name=XE0}
N 740.0 340.0 780.0 340.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 340.0 0 0  {name=l54 sig_type=std_logic lab=AVDD }
N 740.0 360.0 780.0 360.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 360.0 0 0  {name=l55 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/SCX1_CV.sym} 800 400 0 0 {name=XE12}
N 740.0 400.0 780.0 400.0{lab=A12}
C {devices/lab_pin.sym} 740.0 400.0 0 0  {name=l56 sig_type=std_logic lab=A12 }
N 740.0 420.0 780.0 420.0{lab=Y12}
C {devices/lab_pin.sym} 740.0 420.0 0 0  {name=l57 sig_type=std_logic lab=Y12 }
N 740.0 440.0 780.0 440.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 440.0 0 0  {name=l58 sig_type=std_logic lab=AVDD }
N 740.0 460.0 780.0 460.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 460.0 0 0  {name=l59 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/TAPCELLB_CV.sym} 800 500 0 0 {name=XF0}
N 740.0 500.0 780.0 500.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 500.0 0 0  {name=l60 sig_type=std_logic lab=AVDD }
N 740.0 520.0 780.0 520.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 520.0 0 0  {name=l61 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/SWX2_CV.sym} 800 560 0 0 {name=XF13}
N 740.0 560.0 780.0 560.0{lab=A13}
C {devices/lab_pin.sym} 740.0 560.0 0 0  {name=l62 sig_type=std_logic lab=A13 }
N 740.0 580.0 780.0 580.0{lab=Y13}
C {devices/lab_pin.sym} 740.0 580.0 0 0  {name=l63 sig_type=std_logic lab=Y13 }
N 740.0 600.0 780.0 600.0{lab=V13}
C {devices/lab_pin.sym} 740.0 600.0 0 0  {name=l64 sig_type=std_logic lab=V13 }
N 740.0 620.0 780.0 620.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 620.0 0 0  {name=l65 sig_type=std_logic lab=AVDD }
N 740.0 640.0 780.0 640.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 640.0 0 0  {name=l66 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/SWX4_CV.sym} 800 680 0 0 {name=XF14}
N 740.0 680.0 780.0 680.0{lab=A14}
C {devices/lab_pin.sym} 740.0 680.0 0 0  {name=l67 sig_type=std_logic lab=A14 }
N 740.0 700.0 780.0 700.0{lab=Y14}
C {devices/lab_pin.sym} 740.0 700.0 0 0  {name=l68 sig_type=std_logic lab=Y14 }
N 740.0 720.0 780.0 720.0{lab=V14}
C {devices/lab_pin.sym} 740.0 720.0 0 0  {name=l69 sig_type=std_logic lab=V14 }
N 740.0 740.0 780.0 740.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 740.0 0 0  {name=l70 sig_type=std_logic lab=AVDD }
N 740.0 760.0 780.0 760.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 760.0 0 0  {name=l71 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/TGPD_CV.sym} 800 800 0 0 {name=XF15}
N 740.0 800.0 780.0 800.0{lab=A15}
C {devices/lab_pin.sym} 740.0 800.0 0 0  {name=l72 sig_type=std_logic lab=A15 }
N 740.0 820.0 780.0 820.0{lab=Y15}
C {devices/lab_pin.sym} 740.0 820.0 0 0  {name=l73 sig_type=std_logic lab=Y15 }
N 740.0 840.0 780.0 840.0{lab=V15}
C {devices/lab_pin.sym} 740.0 840.0 0 0  {name=l74 sig_type=std_logic lab=V15 }
N 740.0 860.0 780.0 860.0{lab=AVDD}
C {devices/lab_pin.sym} 740.0 860.0 0 0  {name=l75 sig_type=std_logic lab=AVDD }
N 740.0 880.0 780.0 880.0{lab=AVSS}
C {devices/lab_pin.sym} 740.0 880.0 0 0  {name=l76 sig_type=std_logic lab=AVSS }
