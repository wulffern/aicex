v {xschem version=3.0.0 file_version=1.2 }
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=D}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=CK}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=C}
C {devices/iopin.sym} 0 60 0 0{name=p3 lab=CN}
C {devices/iopin.sym} 0 80 0 0{name=p4 lab=Y}
C {devices/iopin.sym} 0 100 0 0{name=p5 lab=AVDD}
C {devices/iopin.sym} 0 120 0 0{name=p6 lab=AVSS}
C {SUN_TR_SK130NM/TAPCELLB_CV.sym} 400 0 0 0 {name=XA3}
N 340.0 0.0 380.0 0.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 0.0 0 0  {name=l0 sig_type=std_logic lab=AVDD }
N 340.0 20.0 380.0 20.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 20.0 0 0  {name=l1 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/DFRNQNX1_CV.sym} 400 60 0 0 {name=XA2}
N 340.0 60.0 380.0 60.0{lab=D}
C {devices/lab_pin.sym} 340.0 60.0 0 0  {name=l2 sig_type=std_logic lab=D }
N 340.0 80.0 380.0 80.0{lab=CK}
C {devices/lab_pin.sym} 340.0 80.0 0 0  {name=l3 sig_type=std_logic lab=CK }
N 340.0 100.0 380.0 100.0{lab=C}
C {devices/lab_pin.sym} 340.0 100.0 0 0  {name=l4 sig_type=std_logic lab=C }
N 340.0 120.0 380.0 120.0{lab=NC}
C {devices/lab_pin.sym} 340.0 120.0 0 0  {name=l5 sig_type=std_logic lab=NC }
N 340.0 140.0 380.0 140.0{lab=QN}
C {devices/lab_pin.sym} 340.0 140.0 0 0  {name=l6 sig_type=std_logic lab=QN }
N 340.0 160.0 380.0 160.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 160.0 0 0  {name=l7 sig_type=std_logic lab=AVDD }
N 340.0 180.0 380.0 180.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 180.0 0 0  {name=l8 sig_type=std_logic lab=AVSS }
C {SUN_TR_SK130NM/IVTRIX1_CV.sym} 400 220 0 0 {name=XA0}
N 340.0 220.0 380.0 220.0{lab=QN}
C {devices/lab_pin.sym} 340.0 220.0 0 0  {name=l9 sig_type=std_logic lab=QN }
N 340.0 240.0 380.0 240.0{lab=C}
C {devices/lab_pin.sym} 340.0 240.0 0 0  {name=l10 sig_type=std_logic lab=C }
N 340.0 260.0 380.0 260.0{lab=CN}
C {devices/lab_pin.sym} 340.0 260.0 0 0  {name=l11 sig_type=std_logic lab=CN }
N 340.0 280.0 380.0 280.0{lab=Y}
C {devices/lab_pin.sym} 340.0 280.0 0 0  {name=l12 sig_type=std_logic lab=Y }
N 340.0 300.0 380.0 300.0{lab=AVDD}
C {devices/lab_pin.sym} 340.0 300.0 0 0  {name=l13 sig_type=std_logic lab=AVDD }
N 340.0 320.0 380.0 320.0{lab=AVSS}
C {devices/lab_pin.sym} 340.0 320.0 0 0  {name=l14 sig_type=std_logic lab=AVSS }
