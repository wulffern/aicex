.lib Gt

.endl
