v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=A}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=B}
C {sky130_fd_pr/res_generic_l1.sym} 400 0 0 0 {name=R1
W=0.44
L=0.36
model=res_generic_l1
mult=1}
