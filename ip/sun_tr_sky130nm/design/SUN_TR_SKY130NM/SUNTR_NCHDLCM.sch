v {xschem version=3.0.0 file_version=1.2 }
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=D}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=G}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=S}
C {devices/iopin.sym} 0 60 0 0{name=p3 lab=B}
C {SUN_TR_SKY130NM/SUNTR_NCHDL.sym} 400 0 0 0 {name=M0}
N 340.0 0.0 380.0 0.0{lab=N0}
C {devices/lab_pin.sym} 340.0 0.0 0 0  {name=l0 sig_type=std_logic lab=N0 }
N 340.0 20.0 380.0 20.0{lab=G}
C {devices/lab_pin.sym} 340.0 20.0 0 0  {name=l1 sig_type=std_logic lab=G }
N 340.0 40.0 380.0 40.0{lab=S}
C {devices/lab_pin.sym} 340.0 40.0 0 0  {name=l2 sig_type=std_logic lab=S }
N 460.0 60.0 380.0 60.0{lab=B}
C {devices/lab_pin.sym} 460.0 60.0 0 0  {name=l3 sig_type=std_logic lab=B }
C {SUN_TR_SKY130NM/SUNTR_NCHDL.sym} 400 100 0 0 {name=M1}
N 340.0 100.0 380.0 100.0{lab=N1}
C {devices/lab_pin.sym} 340.0 100.0 0 0  {name=l4 sig_type=std_logic lab=N1 }
N 340.0 120.0 380.0 120.0{lab=G}
C {devices/lab_pin.sym} 340.0 120.0 0 0  {name=l5 sig_type=std_logic lab=G }
N 340.0 140.0 380.0 140.0{lab=N0}
C {devices/lab_pin.sym} 340.0 140.0 0 0  {name=l6 sig_type=std_logic lab=N0 }
N 460.0 160.0 380.0 160.0{lab=B}
C {devices/lab_pin.sym} 460.0 160.0 0 0  {name=l7 sig_type=std_logic lab=B }
C {SUN_TR_SKY130NM/SUNTR_NCHDL.sym} 400 200 0 0 {name=M2}
N 340.0 200.0 380.0 200.0{lab=N2}
C {devices/lab_pin.sym} 340.0 200.0 0 0  {name=l8 sig_type=std_logic lab=N2 }
N 340.0 220.0 380.0 220.0{lab=G}
C {devices/lab_pin.sym} 340.0 220.0 0 0  {name=l9 sig_type=std_logic lab=G }
N 340.0 240.0 380.0 240.0{lab=N1}
C {devices/lab_pin.sym} 340.0 240.0 0 0  {name=l10 sig_type=std_logic lab=N1 }
N 460.0 260.0 380.0 260.0{lab=B}
C {devices/lab_pin.sym} 460.0 260.0 0 0  {name=l11 sig_type=std_logic lab=B }
C {SUN_TR_SKY130NM/SUNTR_NCHDL.sym} 400 300 0 0 {name=M3}
N 340.0 300.0 380.0 300.0{lab=N3}
C {devices/lab_pin.sym} 340.0 300.0 0 0  {name=l12 sig_type=std_logic lab=N3 }
N 340.0 320.0 380.0 320.0{lab=G}
C {devices/lab_pin.sym} 340.0 320.0 0 0  {name=l13 sig_type=std_logic lab=G }
N 340.0 340.0 380.0 340.0{lab=N2}
C {devices/lab_pin.sym} 340.0 340.0 0 0  {name=l14 sig_type=std_logic lab=N2 }
N 460.0 360.0 380.0 360.0{lab=B}
C {devices/lab_pin.sym} 460.0 360.0 0 0  {name=l15 sig_type=std_logic lab=B }
C {SUN_TR_SKY130NM/SUNTR_NCHDL.sym} 400 400 0 0 {name=M4}
N 340.0 400.0 380.0 400.0{lab=N4}
C {devices/lab_pin.sym} 340.0 400.0 0 0  {name=l16 sig_type=std_logic lab=N4 }
N 340.0 420.0 380.0 420.0{lab=G}
C {devices/lab_pin.sym} 340.0 420.0 0 0  {name=l17 sig_type=std_logic lab=G }
N 340.0 440.0 380.0 440.0{lab=N3}
C {devices/lab_pin.sym} 340.0 440.0 0 0  {name=l18 sig_type=std_logic lab=N3 }
N 460.0 460.0 380.0 460.0{lab=B}
C {devices/lab_pin.sym} 460.0 460.0 0 0  {name=l19 sig_type=std_logic lab=B }
C {SUN_TR_SKY130NM/SUNTR_NCHDL.sym} 400 500 0 0 {name=M5}
N 340.0 500.0 380.0 500.0{lab=N5}
C {devices/lab_pin.sym} 340.0 500.0 0 0  {name=l20 sig_type=std_logic lab=N5 }
N 340.0 520.0 380.0 520.0{lab=G}
C {devices/lab_pin.sym} 340.0 520.0 0 0  {name=l21 sig_type=std_logic lab=G }
N 340.0 540.0 380.0 540.0{lab=N4}
C {devices/lab_pin.sym} 340.0 540.0 0 0  {name=l22 sig_type=std_logic lab=N4 }
N 460.0 560.0 380.0 560.0{lab=B}
C {devices/lab_pin.sym} 460.0 560.0 0 0  {name=l23 sig_type=std_logic lab=B }
C {SUN_TR_SKY130NM/SUNTR_NCHDL.sym} 400 600 0 0 {name=M6}
N 340.0 600.0 380.0 600.0{lab=N6}
C {devices/lab_pin.sym} 340.0 600.0 0 0  {name=l24 sig_type=std_logic lab=N6 }
N 340.0 620.0 380.0 620.0{lab=G}
C {devices/lab_pin.sym} 340.0 620.0 0 0  {name=l25 sig_type=std_logic lab=G }
N 340.0 640.0 380.0 640.0{lab=N5}
C {devices/lab_pin.sym} 340.0 640.0 0 0  {name=l26 sig_type=std_logic lab=N5 }
N 460.0 660.0 380.0 660.0{lab=B}
C {devices/lab_pin.sym} 460.0 660.0 0 0  {name=l27 sig_type=std_logic lab=B }
C {SUN_TR_SKY130NM/SUNTR_NCHDL.sym} 400 700 0 0 {name=M7}
N 340.0 700.0 380.0 700.0{lab=N7}
C {devices/lab_pin.sym} 340.0 700.0 0 0  {name=l28 sig_type=std_logic lab=N7 }
N 340.0 720.0 380.0 720.0{lab=G}
C {devices/lab_pin.sym} 340.0 720.0 0 0  {name=l29 sig_type=std_logic lab=G }
N 340.0 740.0 380.0 740.0{lab=N6}
C {devices/lab_pin.sym} 340.0 740.0 0 0  {name=l30 sig_type=std_logic lab=N6 }
N 460.0 760.0 380.0 760.0{lab=B}
C {devices/lab_pin.sym} 460.0 760.0 0 0  {name=l31 sig_type=std_logic lab=B }
C {SUN_TR_SKY130NM/SUNTR_NCHDL.sym} 400 800 0 0 {name=M8}
N 340.0 800.0 380.0 800.0{lab=D}
C {devices/lab_pin.sym} 340.0 800.0 0 0  {name=l32 sig_type=std_logic lab=D }
N 340.0 820.0 380.0 820.0{lab=G}
C {devices/lab_pin.sym} 340.0 820.0 0 0  {name=l33 sig_type=std_logic lab=G }
N 340.0 840.0 380.0 840.0{lab=N7}
C {devices/lab_pin.sym} 340.0 840.0 0 0  {name=l34 sig_type=std_logic lab=N7 }
N 460.0 860.0 380.0 860.0{lab=B}
C {devices/lab_pin.sym} 460.0 860.0 0 0  {name=l35 sig_type=std_logic lab=B }
