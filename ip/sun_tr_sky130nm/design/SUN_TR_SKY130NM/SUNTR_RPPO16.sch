v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=P}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=N}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=B}
C {SUN_TR_SKY130NM/SUNTR_RES16.sym} 400 0 0 0 {name=XXA1}
N 360.0 0.0 380.0 0.0{lab=N}
C {devices/lab_pin.sym} 360.0 0.0 0 0  {name=l0 sig_type=std_logic lab=N }
N 360.0 20.0 380.0 20.0{lab=P}
C {devices/lab_pin.sym} 360.0 20.0 0 0  {name=l1 sig_type=std_logic lab=P }
N 360.0 40.0 380.0 40.0{lab=B}
C {devices/lab_pin.sym} 360.0 40.0 0 0  {name=l2 sig_type=std_logic lab=B }
