v {xschem version=3.0.0 file_version=1.2 }
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=D}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=G}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=S}
C {devices/iopin.sym} 0 60 0 0{name=p3 lab=B}
C {SUN_TR_SKY130NM/SUNTR_NCHDLCM.sym} 400 0 0 0 {name=M0}
N 340.0 0.0 380.0 0.0{lab=D}
C {devices/lab_pin.sym} 340.0 0.0 0 0  {name=l0 sig_type=std_logic lab=D }
N 340.0 20.0 380.0 20.0{lab=G}
C {devices/lab_pin.sym} 340.0 20.0 0 0  {name=l1 sig_type=std_logic lab=G }
N 340.0 40.0 380.0 40.0{lab=S}
C {devices/lab_pin.sym} 340.0 40.0 0 0  {name=l2 sig_type=std_logic lab=S }
N 340.0 60.0 380.0 60.0{lab=B}
C {devices/lab_pin.sym} 340.0 60.0 0 0  {name=l3 sig_type=std_logic lab=B }
C {SUN_TR_SKY130NM/SUNTR_NCHDLCM.sym} 400 100 0 0 {name=M1}
N 340.0 100.0 380.0 100.0{lab=S}
C {devices/lab_pin.sym} 340.0 100.0 0 0  {name=l4 sig_type=std_logic lab=S }
N 340.0 120.0 380.0 120.0{lab=G}
C {devices/lab_pin.sym} 340.0 120.0 0 0  {name=l5 sig_type=std_logic lab=G }
N 340.0 140.0 380.0 140.0{lab=D}
C {devices/lab_pin.sym} 340.0 140.0 0 0  {name=l6 sig_type=std_logic lab=D }
N 340.0 160.0 380.0 160.0{lab=B}
C {devices/lab_pin.sym} 340.0 160.0 0 0  {name=l7 sig_type=std_logic lab=B }
