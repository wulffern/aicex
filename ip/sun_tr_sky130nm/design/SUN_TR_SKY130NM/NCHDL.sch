v {xschem version=3.0.0 file_version=1.2 }
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=D}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=G}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=S}
C {devices/iopin.sym} 0 60 0 0{name=p3 lab=B}
