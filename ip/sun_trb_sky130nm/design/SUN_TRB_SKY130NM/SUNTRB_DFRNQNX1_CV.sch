v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=D}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=CK}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=RN}
C {devices/iopin.sym} 0 60 0 0{name=p3 lab=Q}
C {devices/iopin.sym} 0 80 0 0{name=p4 lab=QN}
C {devices/iopin.sym} 0 100 0 0{name=p5 lab=BULKP}
C {devices/iopin.sym} 0 120 0 0{name=p6 lab=BULKN}
C {devices/iopin.sym} 0 140 0 0{name=p7 lab=AVDD}
C {devices/iopin.sym} 0 160 0 0{name=p8 lab=AVSS}
C {SUN_TRB_SKY130NM/SUNTRB_TAPCELLBAVSS_CV.sym} 400 0 0 0 {name=XXA0}
N 360.0 0.0 380.0 0.0{lab=BULKP}
C {devices/lab_pin.sym} 360.0 0.0 0 0  {name=l0 sig_type=std_logic lab=BULKP }
N 360.0 20.0 380.0 20.0{lab=BULKN}
C {devices/lab_pin.sym} 360.0 20.0 0 0  {name=l1 sig_type=std_logic lab=BULKN }
C {SUN_TRB_SKY130NM/SUNTRB_NDX1_CV.sym} 400 140.0 0 0 {name=XXA1}
N 380.0 120.0 400.0 120.0{lab=CK}
C {devices/lab_pin.sym} 380.0 120.0 0 0  {name=l2 sig_type=std_logic lab=CK }
N 380.0 140.0 400.0 140.0{lab=RN}
C {devices/lab_pin.sym} 380.0 140.0 0 0  {name=l3 sig_type=std_logic lab=RN }
N 510.0 130.0 490.0 130.0{lab=CKN}
C {devices/lab_pin.sym} 510.0 130.0 2 0  {name=l4 sig_type=std_logic lab=CKN }
N 480.0 90.0 460.0 90.0{lab=BULKP}
C {devices/lab_pin.sym} 480.0 90.0 2 0  {name=l5 sig_type=std_logic lab=BULKP }
N 480.0 170.0 460.0 170.0{lab=BULKN}
C {devices/lab_pin.sym} 480.0 170.0 2 0  {name=l6 sig_type=std_logic lab=BULKN }
N 420.0 90.0 440.0 90.0{lab=AVDD}
C {devices/lab_pin.sym} 420.0 90.0 0 0  {name=l7 sig_type=std_logic lab=AVDD }
N 420.0 170.0 440.0 170.0{lab=AVSS}
C {devices/lab_pin.sym} 420.0 170.0 0 0  {name=l8 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVX1_CV.sym} 400 330.0 0 0 {name=XXA2}
N 380.0 330.0 400.0 330.0{lab=CKN}
C {devices/lab_pin.sym} 380.0 330.0 0 0  {name=l9 sig_type=std_logic lab=CKN }
N 500.0 330.0 480.0 330.0{lab=CKB}
C {devices/lab_pin.sym} 500.0 330.0 2 0  {name=l10 sig_type=std_logic lab=CKB }
N 470.0 290.0 450.0 290.0{lab=BULKP}
C {devices/lab_pin.sym} 470.0 290.0 2 0  {name=l11 sig_type=std_logic lab=BULKP }
N 470.0 370.0 450.0 370.0{lab=BULKN}
C {devices/lab_pin.sym} 470.0 370.0 2 0  {name=l12 sig_type=std_logic lab=BULKN }
N 410.0 290.0 430.0 290.0{lab=AVDD}
C {devices/lab_pin.sym} 410.0 290.0 0 0  {name=l13 sig_type=std_logic lab=AVDD }
N 410.0 370.0 430.0 370.0{lab=AVSS}
C {devices/lab_pin.sym} 410.0 370.0 0 0  {name=l14 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVTRIX1_CV.sym} 400 520.0 0 0 {name=XXA3}
N 360.0 520.0 380.0 520.0{lab=D}
C {devices/lab_pin.sym} 360.0 520.0 0 0  {name=l15 sig_type=std_logic lab=D }
N 360.0 540.0 380.0 540.0{lab=CKN}
C {devices/lab_pin.sym} 360.0 540.0 0 0  {name=l16 sig_type=std_logic lab=CKN }
N 360.0 560.0 380.0 560.0{lab=CKB}
C {devices/lab_pin.sym} 360.0 560.0 0 0  {name=l17 sig_type=std_logic lab=CKB }
N 360.0 580.0 380.0 580.0{lab=A0}
C {devices/lab_pin.sym} 360.0 580.0 0 0  {name=l18 sig_type=std_logic lab=A0 }
N 360.0 600.0 380.0 600.0{lab=BULKP}
C {devices/lab_pin.sym} 360.0 600.0 0 0  {name=l19 sig_type=std_logic lab=BULKP }
N 360.0 620.0 380.0 620.0{lab=BULKN}
C {devices/lab_pin.sym} 360.0 620.0 0 0  {name=l20 sig_type=std_logic lab=BULKN }
N 360.0 640.0 380.0 640.0{lab=AVDD}
C {devices/lab_pin.sym} 360.0 640.0 0 0  {name=l21 sig_type=std_logic lab=AVDD }
N 360.0 660.0 380.0 660.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 660.0 0 0  {name=l22 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVTRIX1_CV.sym} 400 780.0 0 0 {name=XXA4}
N 360.0 780.0 380.0 780.0{lab=A1}
C {devices/lab_pin.sym} 360.0 780.0 0 0  {name=l23 sig_type=std_logic lab=A1 }
N 360.0 800.0 380.0 800.0{lab=CKB}
C {devices/lab_pin.sym} 360.0 800.0 0 0  {name=l24 sig_type=std_logic lab=CKB }
N 360.0 820.0 380.0 820.0{lab=CKN}
C {devices/lab_pin.sym} 360.0 820.0 0 0  {name=l25 sig_type=std_logic lab=CKN }
N 360.0 840.0 380.0 840.0{lab=A0}
C {devices/lab_pin.sym} 360.0 840.0 0 0  {name=l26 sig_type=std_logic lab=A0 }
N 360.0 860.0 380.0 860.0{lab=BULKP}
C {devices/lab_pin.sym} 360.0 860.0 0 0  {name=l27 sig_type=std_logic lab=BULKP }
N 360.0 880.0 380.0 880.0{lab=BULKN}
C {devices/lab_pin.sym} 360.0 880.0 0 0  {name=l28 sig_type=std_logic lab=BULKN }
N 360.0 900.0 380.0 900.0{lab=AVDD}
C {devices/lab_pin.sym} 360.0 900.0 0 0  {name=l29 sig_type=std_logic lab=AVDD }
N 360.0 920.0 380.0 920.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 920.0 0 0  {name=l30 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVX1_CV.sym} 900 0 0 0 {name=XXA5}
N 880.0 0.0 900.0 0.0{lab=A0}
C {devices/lab_pin.sym} 880.0 0.0 0 0  {name=l31 sig_type=std_logic lab=A0 }
N 1000.0 0.0 980.0 0.0{lab=A1}
C {devices/lab_pin.sym} 1000.0 0.0 2 0  {name=l32 sig_type=std_logic lab=A1 }
N 970.0 -40.0 950.0 -40.0{lab=BULKP}
C {devices/lab_pin.sym} 970.0 -40.0 2 0  {name=l33 sig_type=std_logic lab=BULKP }
N 970.0 40.0 950.0 40.0{lab=BULKN}
C {devices/lab_pin.sym} 970.0 40.0 2 0  {name=l34 sig_type=std_logic lab=BULKN }
N 910.0 -40.0 930.0 -40.0{lab=AVDD}
C {devices/lab_pin.sym} 910.0 -40.0 0 0  {name=l35 sig_type=std_logic lab=AVDD }
N 910.0 40.0 930.0 40.0{lab=AVSS}
C {devices/lab_pin.sym} 910.0 40.0 0 0  {name=l36 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVTRIX1_CV.sym} 900 190.0 0 0 {name=XXA6}
N 860.0 190.0 880.0 190.0{lab=A1}
C {devices/lab_pin.sym} 860.0 190.0 0 0  {name=l37 sig_type=std_logic lab=A1 }
N 860.0 210.0 880.0 210.0{lab=CKB}
C {devices/lab_pin.sym} 860.0 210.0 0 0  {name=l38 sig_type=std_logic lab=CKB }
N 860.0 230.0 880.0 230.0{lab=CKN}
C {devices/lab_pin.sym} 860.0 230.0 0 0  {name=l39 sig_type=std_logic lab=CKN }
N 860.0 250.0 880.0 250.0{lab=QN}
C {devices/lab_pin.sym} 860.0 250.0 0 0  {name=l40 sig_type=std_logic lab=QN }
N 860.0 270.0 880.0 270.0{lab=BULKP}
C {devices/lab_pin.sym} 860.0 270.0 0 0  {name=l41 sig_type=std_logic lab=BULKP }
N 860.0 290.0 880.0 290.0{lab=BULKN}
C {devices/lab_pin.sym} 860.0 290.0 0 0  {name=l42 sig_type=std_logic lab=BULKN }
N 860.0 310.0 880.0 310.0{lab=AVDD}
C {devices/lab_pin.sym} 860.0 310.0 0 0  {name=l43 sig_type=std_logic lab=AVDD }
N 860.0 330.0 880.0 330.0{lab=AVSS}
C {devices/lab_pin.sym} 860.0 330.0 0 0  {name=l44 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_NDTRIX1_CV.sym} 900 450.0 0 0 {name=XXA7}
N 860.0 450.0 880.0 450.0{lab=Q}
C {devices/lab_pin.sym} 860.0 450.0 0 0  {name=l45 sig_type=std_logic lab=Q }
N 860.0 470.0 880.0 470.0{lab=CKN}
C {devices/lab_pin.sym} 860.0 470.0 0 0  {name=l46 sig_type=std_logic lab=CKN }
N 860.0 490.0 880.0 490.0{lab=CKB}
C {devices/lab_pin.sym} 860.0 490.0 0 0  {name=l47 sig_type=std_logic lab=CKB }
N 860.0 510.0 880.0 510.0{lab=RN}
C {devices/lab_pin.sym} 860.0 510.0 0 0  {name=l48 sig_type=std_logic lab=RN }
N 860.0 530.0 880.0 530.0{lab=QN}
C {devices/lab_pin.sym} 860.0 530.0 0 0  {name=l49 sig_type=std_logic lab=QN }
N 860.0 550.0 880.0 550.0{lab=BULKP}
C {devices/lab_pin.sym} 860.0 550.0 0 0  {name=l50 sig_type=std_logic lab=BULKP }
N 860.0 570.0 880.0 570.0{lab=BULKN}
C {devices/lab_pin.sym} 860.0 570.0 0 0  {name=l51 sig_type=std_logic lab=BULKN }
N 860.0 590.0 880.0 590.0{lab=AVDD}
C {devices/lab_pin.sym} 860.0 590.0 0 0  {name=l52 sig_type=std_logic lab=AVDD }
N 860.0 610.0 880.0 610.0{lab=AVSS}
C {devices/lab_pin.sym} 860.0 610.0 0 0  {name=l53 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVX1_CV.sym} 900 730.0 0 0 {name=XXA8}
N 880.0 730.0 900.0 730.0{lab=QN}
C {devices/lab_pin.sym} 880.0 730.0 0 0  {name=l54 sig_type=std_logic lab=QN }
N 1000.0 730.0 980.0 730.0{lab=Q}
C {devices/lab_pin.sym} 1000.0 730.0 2 0  {name=l55 sig_type=std_logic lab=Q }
N 970.0 690.0 950.0 690.0{lab=BULKP}
C {devices/lab_pin.sym} 970.0 690.0 2 0  {name=l56 sig_type=std_logic lab=BULKP }
N 970.0 770.0 950.0 770.0{lab=BULKN}
C {devices/lab_pin.sym} 970.0 770.0 2 0  {name=l57 sig_type=std_logic lab=BULKN }
N 910.0 690.0 930.0 690.0{lab=AVDD}
C {devices/lab_pin.sym} 910.0 690.0 0 0  {name=l58 sig_type=std_logic lab=AVDD }
N 910.0 770.0 930.0 770.0{lab=AVSS}
C {devices/lab_pin.sym} 910.0 770.0 0 0  {name=l59 sig_type=std_logic lab=AVSS }
