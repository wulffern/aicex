v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=D}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=CK}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=RN}
C {devices/iopin.sym} 0 60 0 0{name=p3 lab=Q}
C {devices/iopin.sym} 0 80 0 0{name=p4 lab=QN}
C {devices/iopin.sym} 0 100 0 0{name=p5 lab=BULKP}
C {devices/iopin.sym} 0 120 0 0{name=p6 lab=BULKN}
C {devices/iopin.sym} 0 140 0 0{name=p7 lab=AVDD}
C {devices/iopin.sym} 0 160 0 0{name=p8 lab=AVSS}
C {SUN_TRB_SKY130NM/SUNTRB_NDX1_CV.sym} 400 0 0 0 {name=XXA1}
N 380.0 -20.0 400.0 -20.0{lab=CK}
C {devices/lab_pin.sym} 380.0 -20.0 0 0  {name=l0 sig_type=std_logic lab=CK }
N 380.0 0.0 400.0 0.0{lab=RN}
C {devices/lab_pin.sym} 380.0 0.0 0 0  {name=l1 sig_type=std_logic lab=RN }
N 510.0 -10.0 490.0 -10.0{lab=CKN}
C {devices/lab_pin.sym} 510.0 -10.0 2 0  {name=l2 sig_type=std_logic lab=CKN }
N 480.0 -50.0 460.0 -50.0{lab=BULKP}
C {devices/lab_pin.sym} 480.0 -50.0 2 0  {name=l3 sig_type=std_logic lab=BULKP }
N 480.0 30.0 460.0 30.0{lab=BULKN}
C {devices/lab_pin.sym} 480.0 30.0 2 0  {name=l4 sig_type=std_logic lab=BULKN }
N 420.0 -50.0 440.0 -50.0{lab=AVDD}
C {devices/lab_pin.sym} 420.0 -50.0 0 0  {name=l5 sig_type=std_logic lab=AVDD }
N 420.0 30.0 440.0 30.0{lab=AVSS}
C {devices/lab_pin.sym} 420.0 30.0 0 0  {name=l6 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVX1_CV.sym} 400 128.0 0 0 {name=XXA2}
N 380.0 128.0 400.0 128.0{lab=CKN}
C {devices/lab_pin.sym} 380.0 128.0 0 0  {name=l7 sig_type=std_logic lab=CKN }
N 500.0 128.0 480.0 128.0{lab=CKB}
C {devices/lab_pin.sym} 500.0 128.0 2 0  {name=l8 sig_type=std_logic lab=CKB }
N 470.0 88.0 450.0 88.0{lab=BULKP}
C {devices/lab_pin.sym} 470.0 88.0 2 0  {name=l9 sig_type=std_logic lab=BULKP }
N 470.0 168.0 450.0 168.0{lab=BULKN}
C {devices/lab_pin.sym} 470.0 168.0 2 0  {name=l10 sig_type=std_logic lab=BULKN }
N 410.0 88.0 430.0 88.0{lab=AVDD}
C {devices/lab_pin.sym} 410.0 88.0 0 0  {name=l11 sig_type=std_logic lab=AVDD }
N 410.0 168.0 430.0 168.0{lab=AVSS}
C {devices/lab_pin.sym} 410.0 168.0 0 0  {name=l12 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVTRIX1_CV.sym} 400 256.0 0 0 {name=XXA3}
N 360.0 256.0 380.0 256.0{lab=D}
C {devices/lab_pin.sym} 360.0 256.0 0 0  {name=l13 sig_type=std_logic lab=D }
N 360.0 276.0 380.0 276.0{lab=CKN}
C {devices/lab_pin.sym} 360.0 276.0 0 0  {name=l14 sig_type=std_logic lab=CKN }
N 360.0 296.0 380.0 296.0{lab=CKB}
C {devices/lab_pin.sym} 360.0 296.0 0 0  {name=l15 sig_type=std_logic lab=CKB }
N 360.0 316.0 380.0 316.0{lab=A0}
C {devices/lab_pin.sym} 360.0 316.0 0 0  {name=l16 sig_type=std_logic lab=A0 }
N 360.0 336.0 380.0 336.0{lab=BULKP}
C {devices/lab_pin.sym} 360.0 336.0 0 0  {name=l17 sig_type=std_logic lab=BULKP }
N 360.0 356.0 380.0 356.0{lab=BULKN}
C {devices/lab_pin.sym} 360.0 356.0 0 0  {name=l18 sig_type=std_logic lab=BULKN }
N 360.0 376.0 380.0 376.0{lab=AVDD}
C {devices/lab_pin.sym} 360.0 376.0 0 0  {name=l19 sig_type=std_logic lab=AVDD }
N 360.0 396.0 380.0 396.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 396.0 0 0  {name=l20 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVTRIX1_CV.sym} 400 456.0 0 0 {name=XXA4}
N 360.0 456.0 380.0 456.0{lab=A1}
C {devices/lab_pin.sym} 360.0 456.0 0 0  {name=l21 sig_type=std_logic lab=A1 }
N 360.0 476.0 380.0 476.0{lab=CKB}
C {devices/lab_pin.sym} 360.0 476.0 0 0  {name=l22 sig_type=std_logic lab=CKB }
N 360.0 496.0 380.0 496.0{lab=CKN}
C {devices/lab_pin.sym} 360.0 496.0 0 0  {name=l23 sig_type=std_logic lab=CKN }
N 360.0 516.0 380.0 516.0{lab=A0}
C {devices/lab_pin.sym} 360.0 516.0 0 0  {name=l24 sig_type=std_logic lab=A0 }
N 360.0 536.0 380.0 536.0{lab=BULKP}
C {devices/lab_pin.sym} 360.0 536.0 0 0  {name=l25 sig_type=std_logic lab=BULKP }
N 360.0 556.0 380.0 556.0{lab=BULKN}
C {devices/lab_pin.sym} 360.0 556.0 0 0  {name=l26 sig_type=std_logic lab=BULKN }
N 360.0 576.0 380.0 576.0{lab=AVDD}
C {devices/lab_pin.sym} 360.0 576.0 0 0  {name=l27 sig_type=std_logic lab=AVDD }
N 360.0 596.0 380.0 596.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 596.0 0 0  {name=l28 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVX1_CV.sym} 400 656.0 0 0 {name=XXA5}
N 380.0 656.0 400.0 656.0{lab=A0}
C {devices/lab_pin.sym} 380.0 656.0 0 0  {name=l29 sig_type=std_logic lab=A0 }
N 500.0 656.0 480.0 656.0{lab=A1}
C {devices/lab_pin.sym} 500.0 656.0 2 0  {name=l30 sig_type=std_logic lab=A1 }
N 470.0 616.0 450.0 616.0{lab=BULKP}
C {devices/lab_pin.sym} 470.0 616.0 2 0  {name=l31 sig_type=std_logic lab=BULKP }
N 470.0 696.0 450.0 696.0{lab=BULKN}
C {devices/lab_pin.sym} 470.0 696.0 2 0  {name=l32 sig_type=std_logic lab=BULKN }
N 410.0 616.0 430.0 616.0{lab=AVDD}
C {devices/lab_pin.sym} 410.0 616.0 0 0  {name=l33 sig_type=std_logic lab=AVDD }
N 410.0 696.0 430.0 696.0{lab=AVSS}
C {devices/lab_pin.sym} 410.0 696.0 0 0  {name=l34 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVTRIX1_CV.sym} 400 784.0 0 0 {name=XXA6}
N 360.0 784.0 380.0 784.0{lab=A1}
C {devices/lab_pin.sym} 360.0 784.0 0 0  {name=l35 sig_type=std_logic lab=A1 }
N 360.0 804.0 380.0 804.0{lab=CKB}
C {devices/lab_pin.sym} 360.0 804.0 0 0  {name=l36 sig_type=std_logic lab=CKB }
N 360.0 824.0 380.0 824.0{lab=CKN}
C {devices/lab_pin.sym} 360.0 824.0 0 0  {name=l37 sig_type=std_logic lab=CKN }
N 360.0 844.0 380.0 844.0{lab=QN}
C {devices/lab_pin.sym} 360.0 844.0 0 0  {name=l38 sig_type=std_logic lab=QN }
N 360.0 864.0 380.0 864.0{lab=BULKP}
C {devices/lab_pin.sym} 360.0 864.0 0 0  {name=l39 sig_type=std_logic lab=BULKP }
N 360.0 884.0 380.0 884.0{lab=BULKN}
C {devices/lab_pin.sym} 360.0 884.0 0 0  {name=l40 sig_type=std_logic lab=BULKN }
N 360.0 904.0 380.0 904.0{lab=AVDD}
C {devices/lab_pin.sym} 360.0 904.0 0 0  {name=l41 sig_type=std_logic lab=AVDD }
N 360.0 924.0 380.0 924.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 924.0 0 0  {name=l42 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_NDTRIX1_CV.sym} 400 984.0 0 0 {name=XXA7}
N 360.0 984.0 380.0 984.0{lab=Q}
C {devices/lab_pin.sym} 360.0 984.0 0 0  {name=l43 sig_type=std_logic lab=Q }
N 360.0 1004.0 380.0 1004.0{lab=CKN}
C {devices/lab_pin.sym} 360.0 1004.0 0 0  {name=l44 sig_type=std_logic lab=CKN }
N 360.0 1024.0 380.0 1024.0{lab=CKB}
C {devices/lab_pin.sym} 360.0 1024.0 0 0  {name=l45 sig_type=std_logic lab=CKB }
N 360.0 1044.0 380.0 1044.0{lab=RN}
C {devices/lab_pin.sym} 360.0 1044.0 0 0  {name=l46 sig_type=std_logic lab=RN }
N 360.0 1064.0 380.0 1064.0{lab=QN}
C {devices/lab_pin.sym} 360.0 1064.0 0 0  {name=l47 sig_type=std_logic lab=QN }
N 360.0 1084.0 380.0 1084.0{lab=BULKP}
C {devices/lab_pin.sym} 360.0 1084.0 0 0  {name=l48 sig_type=std_logic lab=BULKP }
N 360.0 1104.0 380.0 1104.0{lab=BULKN}
C {devices/lab_pin.sym} 360.0 1104.0 0 0  {name=l49 sig_type=std_logic lab=BULKN }
N 360.0 1124.0 380.0 1124.0{lab=AVDD}
C {devices/lab_pin.sym} 360.0 1124.0 0 0  {name=l50 sig_type=std_logic lab=AVDD }
N 360.0 1144.0 380.0 1144.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 1144.0 0 0  {name=l51 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVX1_CV.sym} 800 0 0 0 {name=XXA8}
N 780.0 0.0 800.0 0.0{lab=QN}
C {devices/lab_pin.sym} 780.0 0.0 0 0  {name=l52 sig_type=std_logic lab=QN }
N 900.0 0.0 880.0 0.0{lab=Q}
C {devices/lab_pin.sym} 900.0 0.0 2 0  {name=l53 sig_type=std_logic lab=Q }
N 870.0 -40.0 850.0 -40.0{lab=BULKP}
C {devices/lab_pin.sym} 870.0 -40.0 2 0  {name=l54 sig_type=std_logic lab=BULKP }
N 870.0 40.0 850.0 40.0{lab=BULKN}
C {devices/lab_pin.sym} 870.0 40.0 2 0  {name=l55 sig_type=std_logic lab=BULKN }
N 810.0 -40.0 830.0 -40.0{lab=AVDD}
C {devices/lab_pin.sym} 810.0 -40.0 0 0  {name=l56 sig_type=std_logic lab=AVDD }
N 810.0 40.0 830.0 40.0{lab=AVSS}
C {devices/lab_pin.sym} 810.0 40.0 0 0  {name=l57 sig_type=std_logic lab=AVSS }
