v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=D}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=CK}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=RN}
C {devices/iopin.sym} 0 60 0 0{name=p3 lab=Q}
C {devices/iopin.sym} 0 80 0 0{name=p4 lab=QN}
C {devices/iopin.sym} 0 100 0 0{name=p5 lab=BULKP}
C {devices/iopin.sym} 0 120 0 0{name=p6 lab=BULKN}
C {devices/iopin.sym} 0 140 0 0{name=p7 lab=AVDD}
C {devices/iopin.sym} 0 160 0 0{name=p8 lab=AVSS}
C {SUN_TRB_SKY130NM/SUNTRB_NDX1_CV.sym} 400 0 0 0 {name=XXA1}
N 380.0 -20.0 400.0 -20.0{lab=CK}
C {devices/lab_pin.sym} 380.0 -20.0 0 0  {name=l0 sig_type=std_logic lab=CK }
N 380.0 0.0 400.0 0.0{lab=RN}
C {devices/lab_pin.sym} 380.0 0.0 0 0  {name=l1 sig_type=std_logic lab=RN }
N 510.0 -10.0 490.0 -10.0{lab=CKN}
C {devices/lab_pin.sym} 510.0 -10.0 2 0  {name=l2 sig_type=std_logic lab=CKN }
N 480.0 -50.0 460.0 -50.0{lab=BULKP}
C {devices/lab_pin.sym} 480.0 -50.0 2 0  {name=l3 sig_type=std_logic lab=BULKP }
N 480.0 30.0 460.0 30.0{lab=BULKN}
C {devices/lab_pin.sym} 480.0 30.0 2 0  {name=l4 sig_type=std_logic lab=BULKN }
N 420.0 -50.0 440.0 -50.0{lab=AVDD}
C {devices/lab_pin.sym} 420.0 -50.0 0 0  {name=l5 sig_type=std_logic lab=AVDD }
N 420.0 30.0 440.0 30.0{lab=AVSS}
C {devices/lab_pin.sym} 420.0 30.0 0 0  {name=l6 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVX1_CV.sym} 400 190.0 0 0 {name=XXA2}
N 380.0 190.0 400.0 190.0{lab=CKN}
C {devices/lab_pin.sym} 380.0 190.0 0 0  {name=l7 sig_type=std_logic lab=CKN }
N 500.0 190.0 480.0 190.0{lab=CKB}
C {devices/lab_pin.sym} 500.0 190.0 2 0  {name=l8 sig_type=std_logic lab=CKB }
N 470.0 150.0 450.0 150.0{lab=BULKP}
C {devices/lab_pin.sym} 470.0 150.0 2 0  {name=l9 sig_type=std_logic lab=BULKP }
N 470.0 230.0 450.0 230.0{lab=BULKN}
C {devices/lab_pin.sym} 470.0 230.0 2 0  {name=l10 sig_type=std_logic lab=BULKN }
N 410.0 150.0 430.0 150.0{lab=AVDD}
C {devices/lab_pin.sym} 410.0 150.0 0 0  {name=l11 sig_type=std_logic lab=AVDD }
N 410.0 230.0 430.0 230.0{lab=AVSS}
C {devices/lab_pin.sym} 410.0 230.0 0 0  {name=l12 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVTRIX1_CV.sym} 400 380.0 0 0 {name=XXA3}
N 360.0 380.0 380.0 380.0{lab=D}
C {devices/lab_pin.sym} 360.0 380.0 0 0  {name=l13 sig_type=std_logic lab=D }
N 360.0 400.0 380.0 400.0{lab=CKN}
C {devices/lab_pin.sym} 360.0 400.0 0 0  {name=l14 sig_type=std_logic lab=CKN }
N 360.0 420.0 380.0 420.0{lab=CKB}
C {devices/lab_pin.sym} 360.0 420.0 0 0  {name=l15 sig_type=std_logic lab=CKB }
N 360.0 440.0 380.0 440.0{lab=A0}
C {devices/lab_pin.sym} 360.0 440.0 0 0  {name=l16 sig_type=std_logic lab=A0 }
N 360.0 460.0 380.0 460.0{lab=BULKP}
C {devices/lab_pin.sym} 360.0 460.0 0 0  {name=l17 sig_type=std_logic lab=BULKP }
N 360.0 480.0 380.0 480.0{lab=BULKN}
C {devices/lab_pin.sym} 360.0 480.0 0 0  {name=l18 sig_type=std_logic lab=BULKN }
N 360.0 500.0 380.0 500.0{lab=AVDD}
C {devices/lab_pin.sym} 360.0 500.0 0 0  {name=l19 sig_type=std_logic lab=AVDD }
N 360.0 520.0 380.0 520.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 520.0 0 0  {name=l20 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVTRIX1_CV.sym} 400 640.0 0 0 {name=XXA4}
N 360.0 640.0 380.0 640.0{lab=A1}
C {devices/lab_pin.sym} 360.0 640.0 0 0  {name=l21 sig_type=std_logic lab=A1 }
N 360.0 660.0 380.0 660.0{lab=CKB}
C {devices/lab_pin.sym} 360.0 660.0 0 0  {name=l22 sig_type=std_logic lab=CKB }
N 360.0 680.0 380.0 680.0{lab=CKN}
C {devices/lab_pin.sym} 360.0 680.0 0 0  {name=l23 sig_type=std_logic lab=CKN }
N 360.0 700.0 380.0 700.0{lab=A0}
C {devices/lab_pin.sym} 360.0 700.0 0 0  {name=l24 sig_type=std_logic lab=A0 }
N 360.0 720.0 380.0 720.0{lab=BULKP}
C {devices/lab_pin.sym} 360.0 720.0 0 0  {name=l25 sig_type=std_logic lab=BULKP }
N 360.0 740.0 380.0 740.0{lab=BULKN}
C {devices/lab_pin.sym} 360.0 740.0 0 0  {name=l26 sig_type=std_logic lab=BULKN }
N 360.0 760.0 380.0 760.0{lab=AVDD}
C {devices/lab_pin.sym} 360.0 760.0 0 0  {name=l27 sig_type=std_logic lab=AVDD }
N 360.0 780.0 380.0 780.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 780.0 0 0  {name=l28 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVX1_CV.sym} 400 900.0 0 0 {name=XXA5}
N 380.0 900.0 400.0 900.0{lab=A0}
C {devices/lab_pin.sym} 380.0 900.0 0 0  {name=l29 sig_type=std_logic lab=A0 }
N 500.0 900.0 480.0 900.0{lab=A1}
C {devices/lab_pin.sym} 500.0 900.0 2 0  {name=l30 sig_type=std_logic lab=A1 }
N 470.0 860.0 450.0 860.0{lab=BULKP}
C {devices/lab_pin.sym} 470.0 860.0 2 0  {name=l31 sig_type=std_logic lab=BULKP }
N 470.0 940.0 450.0 940.0{lab=BULKN}
C {devices/lab_pin.sym} 470.0 940.0 2 0  {name=l32 sig_type=std_logic lab=BULKN }
N 410.0 860.0 430.0 860.0{lab=AVDD}
C {devices/lab_pin.sym} 410.0 860.0 0 0  {name=l33 sig_type=std_logic lab=AVDD }
N 410.0 940.0 430.0 940.0{lab=AVSS}
C {devices/lab_pin.sym} 410.0 940.0 0 0  {name=l34 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVTRIX1_CV.sym} 900 0 0 0 {name=XXA6}
N 860.0 0.0 880.0 0.0{lab=A1}
C {devices/lab_pin.sym} 860.0 0.0 0 0  {name=l35 sig_type=std_logic lab=A1 }
N 860.0 20.0 880.0 20.0{lab=CKB}
C {devices/lab_pin.sym} 860.0 20.0 0 0  {name=l36 sig_type=std_logic lab=CKB }
N 860.0 40.0 880.0 40.0{lab=CKN}
C {devices/lab_pin.sym} 860.0 40.0 0 0  {name=l37 sig_type=std_logic lab=CKN }
N 860.0 60.0 880.0 60.0{lab=QN}
C {devices/lab_pin.sym} 860.0 60.0 0 0  {name=l38 sig_type=std_logic lab=QN }
N 860.0 80.0 880.0 80.0{lab=BULKP}
C {devices/lab_pin.sym} 860.0 80.0 0 0  {name=l39 sig_type=std_logic lab=BULKP }
N 860.0 100.0 880.0 100.0{lab=BULKN}
C {devices/lab_pin.sym} 860.0 100.0 0 0  {name=l40 sig_type=std_logic lab=BULKN }
N 860.0 120.0 880.0 120.0{lab=AVDD}
C {devices/lab_pin.sym} 860.0 120.0 0 0  {name=l41 sig_type=std_logic lab=AVDD }
N 860.0 140.0 880.0 140.0{lab=AVSS}
C {devices/lab_pin.sym} 860.0 140.0 0 0  {name=l42 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_NDTRIX1_CV.sym} 900 260.0 0 0 {name=XXA7}
N 860.0 260.0 880.0 260.0{lab=Q}
C {devices/lab_pin.sym} 860.0 260.0 0 0  {name=l43 sig_type=std_logic lab=Q }
N 860.0 280.0 880.0 280.0{lab=CKN}
C {devices/lab_pin.sym} 860.0 280.0 0 0  {name=l44 sig_type=std_logic lab=CKN }
N 860.0 300.0 880.0 300.0{lab=CKB}
C {devices/lab_pin.sym} 860.0 300.0 0 0  {name=l45 sig_type=std_logic lab=CKB }
N 860.0 320.0 880.0 320.0{lab=RN}
C {devices/lab_pin.sym} 860.0 320.0 0 0  {name=l46 sig_type=std_logic lab=RN }
N 860.0 340.0 880.0 340.0{lab=QN}
C {devices/lab_pin.sym} 860.0 340.0 0 0  {name=l47 sig_type=std_logic lab=QN }
N 860.0 360.0 880.0 360.0{lab=BULKP}
C {devices/lab_pin.sym} 860.0 360.0 0 0  {name=l48 sig_type=std_logic lab=BULKP }
N 860.0 380.0 880.0 380.0{lab=BULKN}
C {devices/lab_pin.sym} 860.0 380.0 0 0  {name=l49 sig_type=std_logic lab=BULKN }
N 860.0 400.0 880.0 400.0{lab=AVDD}
C {devices/lab_pin.sym} 860.0 400.0 0 0  {name=l50 sig_type=std_logic lab=AVDD }
N 860.0 420.0 880.0 420.0{lab=AVSS}
C {devices/lab_pin.sym} 860.0 420.0 0 0  {name=l51 sig_type=std_logic lab=AVSS }
C {SUN_TRB_SKY130NM/SUNTRB_IVX1_CV.sym} 900 540.0 0 0 {name=XXA8}
N 880.0 540.0 900.0 540.0{lab=QN}
C {devices/lab_pin.sym} 880.0 540.0 0 0  {name=l52 sig_type=std_logic lab=QN }
N 1000.0 540.0 980.0 540.0{lab=Q}
C {devices/lab_pin.sym} 1000.0 540.0 2 0  {name=l53 sig_type=std_logic lab=Q }
N 970.0 500.0 950.0 500.0{lab=BULKP}
C {devices/lab_pin.sym} 970.0 500.0 2 0  {name=l54 sig_type=std_logic lab=BULKP }
N 970.0 580.0 950.0 580.0{lab=BULKN}
C {devices/lab_pin.sym} 970.0 580.0 2 0  {name=l55 sig_type=std_logic lab=BULKN }
N 910.0 500.0 930.0 500.0{lab=AVDD}
C {devices/lab_pin.sym} 910.0 500.0 0 0  {name=l56 sig_type=std_logic lab=AVDD }
N 910.0 580.0 930.0 580.0{lab=AVSS}
C {devices/lab_pin.sym} 910.0 580.0 0 0  {name=l57 sig_type=std_logic lab=AVSS }
