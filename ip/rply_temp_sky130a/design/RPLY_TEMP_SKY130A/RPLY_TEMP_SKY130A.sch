v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {cborder/border_s.sym} 180 40 0 0 {}
C {devices/ipin.sym} -950 -810 0 0 {name=p1 lab=VDD_1V8}
C {devices/ipin.sym} -930 120 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} -940 -730 0 0 {name=p3 lab=PWRUP_1V8}
C {RPLY_TEMP_SKY130A/RPLYTEMP_BG.sym} -580 -490 0 0 {name=x1}
