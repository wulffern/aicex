v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0{name=p0 lab=CP<11>}
C {devices/iopin.sym} 0 20 0 0{name=p1 lab=CP<10>}
C {devices/iopin.sym} 0 40 0 0{name=p2 lab=CP<9>}
C {devices/iopin.sym} 0 60 0 0{name=p3 lab=CP<8>}
C {devices/iopin.sym} 0 80 0 0{name=p4 lab=CP<7>}
C {devices/iopin.sym} 0 100 0 0{name=p5 lab=CP<6>}
C {devices/iopin.sym} 0 120 0 0{name=p6 lab=CP<5>}
C {devices/iopin.sym} 0 140 0 0{name=p7 lab=CP<4>}
C {devices/iopin.sym} 0 160 0 0{name=p8 lab=CP<3>}
C {devices/iopin.sym} 0 180 0 0{name=p9 lab=CP<2>}
C {devices/iopin.sym} 0 200 0 0{name=p10 lab=CP<1>}
C {devices/iopin.sym} 0 220 0 0{name=p11 lab=CP<0>}
C {devices/iopin.sym} 0 240 0 0{name=p12 lab=CTOP}
C {devices/iopin.sym} 0 260 0 0{name=p13 lab=AVSS}
C {SUN_SAR9B_SKY130NM/SUNSAR_CAP32C_CV.sym} 400 0 0 0 {name=XXC1}
N 360.0 0.0 380.0 0.0{lab=CP<10>}
C {devices/lab_pin.sym} 360.0 0.0 0 0  {name=l0 sig_type=std_logic lab=CP<10> }
N 360.0 20.0 380.0 20.0{lab=CP<10>}
C {devices/lab_pin.sym} 360.0 20.0 0 0  {name=l1 sig_type=std_logic lab=CP<10> }
N 360.0 40.0 380.0 40.0{lab=CP<10>}
C {devices/lab_pin.sym} 360.0 40.0 0 0  {name=l2 sig_type=std_logic lab=CP<10> }
N 360.0 60.0 380.0 60.0{lab=CP<10>}
C {devices/lab_pin.sym} 360.0 60.0 0 0  {name=l3 sig_type=std_logic lab=CP<10> }
N 360.0 80.0 380.0 80.0{lab=CP<10>}
C {devices/lab_pin.sym} 360.0 80.0 0 0  {name=l4 sig_type=std_logic lab=CP<10> }
N 360.0 100.0 380.0 100.0{lab=CP<10>}
C {devices/lab_pin.sym} 360.0 100.0 0 0  {name=l5 sig_type=std_logic lab=CP<10> }
N 360.0 120.0 380.0 120.0{lab=CTOP}
C {devices/lab_pin.sym} 360.0 120.0 0 0  {name=l6 sig_type=std_logic lab=CTOP }
N 360.0 140.0 380.0 140.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 140.0 0 0  {name=l7 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SKY130NM/SUNSAR_CAP32C_CV.sym} 400 260.0 0 0 {name=XXC64a<0>}
N 360.0 260.0 380.0 260.0{lab=CP<8>}
C {devices/lab_pin.sym} 360.0 260.0 0 0  {name=l8 sig_type=std_logic lab=CP<8> }
N 360.0 280.0 380.0 280.0{lab=CP<8>}
C {devices/lab_pin.sym} 360.0 280.0 0 0  {name=l9 sig_type=std_logic lab=CP<8> }
N 360.0 300.0 380.0 300.0{lab=CP<8>}
C {devices/lab_pin.sym} 360.0 300.0 0 0  {name=l10 sig_type=std_logic lab=CP<8> }
N 360.0 320.0 380.0 320.0{lab=CP<8>}
C {devices/lab_pin.sym} 360.0 320.0 0 0  {name=l11 sig_type=std_logic lab=CP<8> }
N 360.0 340.0 380.0 340.0{lab=CP<8>}
C {devices/lab_pin.sym} 360.0 340.0 0 0  {name=l12 sig_type=std_logic lab=CP<8> }
N 360.0 360.0 380.0 360.0{lab=CP<8>}
C {devices/lab_pin.sym} 360.0 360.0 0 0  {name=l13 sig_type=std_logic lab=CP<8> }
N 360.0 380.0 380.0 380.0{lab=CTOP}
C {devices/lab_pin.sym} 360.0 380.0 0 0  {name=l14 sig_type=std_logic lab=CTOP }
N 360.0 400.0 380.0 400.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 400.0 0 0  {name=l15 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SKY130NM/SUNSAR_CAP32C_CV.sym} 400 520.0 0 0 {name=XXC32a<0>}
N 360.0 520.0 380.0 520.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 520.0 0 0  {name=l16 sig_type=std_logic lab=AVSS }
N 360.0 540.0 380.0 540.0{lab=CP<0>}
C {devices/lab_pin.sym} 360.0 540.0 0 0  {name=l17 sig_type=std_logic lab=CP<0> }
N 360.0 560.0 380.0 560.0{lab=CP<1>}
C {devices/lab_pin.sym} 360.0 560.0 0 0  {name=l18 sig_type=std_logic lab=CP<1> }
N 360.0 580.0 380.0 580.0{lab=CP<2>}
C {devices/lab_pin.sym} 360.0 580.0 0 0  {name=l19 sig_type=std_logic lab=CP<2> }
N 360.0 600.0 380.0 600.0{lab=CP<3>}
C {devices/lab_pin.sym} 360.0 600.0 0 0  {name=l20 sig_type=std_logic lab=CP<3> }
N 360.0 620.0 380.0 620.0{lab=CP<7>}
C {devices/lab_pin.sym} 360.0 620.0 0 0  {name=l21 sig_type=std_logic lab=CP<7> }
N 360.0 640.0 380.0 640.0{lab=CTOP}
C {devices/lab_pin.sym} 360.0 640.0 0 0  {name=l22 sig_type=std_logic lab=CTOP }
N 360.0 660.0 380.0 660.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 660.0 0 0  {name=l23 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SKY130NM/SUNSAR_CAP32C_CV.sym} 400 780.0 0 0 {name=XXC128a<1>}
N 360.0 780.0 380.0 780.0{lab=CP<11>}
C {devices/lab_pin.sym} 360.0 780.0 0 0  {name=l24 sig_type=std_logic lab=CP<11> }
N 360.0 800.0 380.0 800.0{lab=CP<11>}
C {devices/lab_pin.sym} 360.0 800.0 0 0  {name=l25 sig_type=std_logic lab=CP<11> }
N 360.0 820.0 380.0 820.0{lab=CP<11>}
C {devices/lab_pin.sym} 360.0 820.0 0 0  {name=l26 sig_type=std_logic lab=CP<11> }
N 360.0 840.0 380.0 840.0{lab=CP<11>}
C {devices/lab_pin.sym} 360.0 840.0 0 0  {name=l27 sig_type=std_logic lab=CP<11> }
N 360.0 860.0 380.0 860.0{lab=CP<11>}
C {devices/lab_pin.sym} 360.0 860.0 0 0  {name=l28 sig_type=std_logic lab=CP<11> }
N 360.0 880.0 380.0 880.0{lab=CP<11>}
C {devices/lab_pin.sym} 360.0 880.0 0 0  {name=l29 sig_type=std_logic lab=CP<11> }
N 360.0 900.0 380.0 900.0{lab=CTOP}
C {devices/lab_pin.sym} 360.0 900.0 0 0  {name=l30 sig_type=std_logic lab=CTOP }
N 360.0 920.0 380.0 920.0{lab=AVSS}
C {devices/lab_pin.sym} 360.0 920.0 0 0  {name=l31 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SKY130NM/SUNSAR_CAP32C_CV.sym} 900 0 0 0 {name=XXC128b<2>}
N 860.0 0.0 880.0 0.0{lab=CP<10>}
C {devices/lab_pin.sym} 860.0 0.0 0 0  {name=l32 sig_type=std_logic lab=CP<10> }
N 860.0 20.0 880.0 20.0{lab=CP<10>}
C {devices/lab_pin.sym} 860.0 20.0 0 0  {name=l33 sig_type=std_logic lab=CP<10> }
N 860.0 40.0 880.0 40.0{lab=CP<10>}
C {devices/lab_pin.sym} 860.0 40.0 0 0  {name=l34 sig_type=std_logic lab=CP<10> }
N 860.0 60.0 880.0 60.0{lab=CP<10>}
C {devices/lab_pin.sym} 860.0 60.0 0 0  {name=l35 sig_type=std_logic lab=CP<10> }
N 860.0 80.0 880.0 80.0{lab=CP<10>}
C {devices/lab_pin.sym} 860.0 80.0 0 0  {name=l36 sig_type=std_logic lab=CP<10> }
N 860.0 100.0 880.0 100.0{lab=CP<10>}
C {devices/lab_pin.sym} 860.0 100.0 0 0  {name=l37 sig_type=std_logic lab=CP<10> }
N 860.0 120.0 880.0 120.0{lab=CTOP}
C {devices/lab_pin.sym} 860.0 120.0 0 0  {name=l38 sig_type=std_logic lab=CTOP }
N 860.0 140.0 880.0 140.0{lab=AVSS}
C {devices/lab_pin.sym} 860.0 140.0 0 0  {name=l39 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SKY130NM/SUNSAR_CAP32C_CV.sym} 900 260.0 0 0 {name=XX16ab}
N 860.0 260.0 880.0 260.0{lab=CP<5>}
C {devices/lab_pin.sym} 860.0 260.0 0 0  {name=l40 sig_type=std_logic lab=CP<5> }
N 860.0 280.0 880.0 280.0{lab=CP<5>}
C {devices/lab_pin.sym} 860.0 280.0 0 0  {name=l41 sig_type=std_logic lab=CP<5> }
N 860.0 300.0 880.0 300.0{lab=CP<5>}
C {devices/lab_pin.sym} 860.0 300.0 0 0  {name=l42 sig_type=std_logic lab=CP<5> }
N 860.0 320.0 880.0 320.0{lab=CP<5>}
C {devices/lab_pin.sym} 860.0 320.0 0 0  {name=l43 sig_type=std_logic lab=CP<5> }
N 860.0 340.0 880.0 340.0{lab=CP<4>}
C {devices/lab_pin.sym} 860.0 340.0 0 0  {name=l44 sig_type=std_logic lab=CP<4> }
N 860.0 360.0 880.0 360.0{lab=CP<6>}
C {devices/lab_pin.sym} 860.0 360.0 0 0  {name=l45 sig_type=std_logic lab=CP<6> }
N 860.0 380.0 880.0 380.0{lab=CTOP}
C {devices/lab_pin.sym} 860.0 380.0 0 0  {name=l46 sig_type=std_logic lab=CTOP }
N 860.0 400.0 880.0 400.0{lab=AVSS}
C {devices/lab_pin.sym} 860.0 400.0 0 0  {name=l47 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SKY130NM/SUNSAR_CAP32C_CV.sym} 900 520.0 0 0 {name=XXC64b<1>}
N 860.0 520.0 880.0 520.0{lab=CP<9>}
C {devices/lab_pin.sym} 860.0 520.0 0 0  {name=l48 sig_type=std_logic lab=CP<9> }
N 860.0 540.0 880.0 540.0{lab=CP<9>}
C {devices/lab_pin.sym} 860.0 540.0 0 0  {name=l49 sig_type=std_logic lab=CP<9> }
N 860.0 560.0 880.0 560.0{lab=CP<9>}
C {devices/lab_pin.sym} 860.0 560.0 0 0  {name=l50 sig_type=std_logic lab=CP<9> }
N 860.0 580.0 880.0 580.0{lab=CP<9>}
C {devices/lab_pin.sym} 860.0 580.0 0 0  {name=l51 sig_type=std_logic lab=CP<9> }
N 860.0 600.0 880.0 600.0{lab=CP<9>}
C {devices/lab_pin.sym} 860.0 600.0 0 0  {name=l52 sig_type=std_logic lab=CP<9> }
N 860.0 620.0 880.0 620.0{lab=CP<9>}
C {devices/lab_pin.sym} 860.0 620.0 0 0  {name=l53 sig_type=std_logic lab=CP<9> }
N 860.0 640.0 880.0 640.0{lab=CTOP}
C {devices/lab_pin.sym} 860.0 640.0 0 0  {name=l54 sig_type=std_logic lab=CTOP }
N 860.0 660.0 880.0 660.0{lab=AVSS}
C {devices/lab_pin.sym} 860.0 660.0 0 0  {name=l55 sig_type=std_logic lab=AVSS }
C {SUN_SAR9B_SKY130NM/SUNSAR_CAP32C_CV.sym} 900 780.0 0 0 {name=XXC0}
N 860.0 780.0 880.0 780.0{lab=CP<11>}
C {devices/lab_pin.sym} 860.0 780.0 0 0  {name=l56 sig_type=std_logic lab=CP<11> }
N 860.0 800.0 880.0 800.0{lab=CP<11>}
C {devices/lab_pin.sym} 860.0 800.0 0 0  {name=l57 sig_type=std_logic lab=CP<11> }
N 860.0 820.0 880.0 820.0{lab=CP<11>}
C {devices/lab_pin.sym} 860.0 820.0 0 0  {name=l58 sig_type=std_logic lab=CP<11> }
N 860.0 840.0 880.0 840.0{lab=CP<11>}
C {devices/lab_pin.sym} 860.0 840.0 0 0  {name=l59 sig_type=std_logic lab=CP<11> }
N 860.0 860.0 880.0 860.0{lab=CP<11>}
C {devices/lab_pin.sym} 860.0 860.0 0 0  {name=l60 sig_type=std_logic lab=CP<11> }
N 860.0 880.0 880.0 880.0{lab=CP<11>}
C {devices/lab_pin.sym} 860.0 880.0 0 0  {name=l61 sig_type=std_logic lab=CP<11> }
N 860.0 900.0 880.0 900.0{lab=CTOP}
C {devices/lab_pin.sym} 860.0 900.0 0 0  {name=l62 sig_type=std_logic lab=CTOP }
N 860.0 920.0 880.0 920.0{lab=AVSS}
C {devices/lab_pin.sym} 860.0 920.0 0 0  {name=l63 sig_type=std_logic lab=AVSS }
