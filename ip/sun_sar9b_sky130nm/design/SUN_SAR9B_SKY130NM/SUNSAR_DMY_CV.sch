v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
